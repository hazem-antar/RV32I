* Functional test stimulus file for 10ns period

* TT process corner
.lib "/home/v62893/mydata/OpenRAM/OpenRAM/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "/tmp/openram_v62893_102720_temp/sram.sp"

* Global Power Supplies
Vvdd vdd 0 3.3

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_32b_256_1rw_sky130 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 din0_32 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 SPARE_WEN0_0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout0_32 vdd gnd sram_32b_256_1rw_sky130

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD032 dout0_32  0 27.56f

* Important signals for debug
* bl:	xsram:xbank0:bl_0_0
* br:	xsram:xbank0:br_0_0
* s_en:	xsram:s_en
* q:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q
* qbar:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 0+11111010101111001010101100011111  to  address 011111111 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 0+01111100011000000010010010100011  to  address 000000000 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 0+11110100011110010010001100101110  to  address 011111111 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 0+01111100011000000010010010100011 from address 000000000 (from port 0) during cycle 4 (40ns - 50ns)
*	Writing 0+01001010110101100011110010000111  to  address 011111111 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 0+01111100011000000010010010100011 from address 000000000 (from port 0) during cycle 7 (70ns - 80ns)
*	Reading 0+01111100011000000010010010100011 from address 000000000 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 0+01111100011000000010010010100011 from address 000000000 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 0+01001010110101100011110010000111 from address 011111111 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 0+01111100011000000010010010100011 from address 000000000 (from port 0) during cycle 11 (110ns - 120ns)
*	Writing 0+10001000111000001110001100110110  to  address 000000000 (from port 0) during cycle 12 (120ns - 130ns)
*	Reading 0+10001000111000001110001100110110 from address 000000000 (from port 0) during cycle 13 (130ns - 140ns)
*	Writing 0+00110100101101110111001111001011  to  address 011111111 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 0+00110100101101110111001111001011 from address 011111111 (from port 0) during cycle 15 (150ns - 160ns)
*	Reading 0+10001000111000001110001100110110 from address 000000000 (from port 0) during cycle 17 (170ns - 180ns)
*	Writing 0+01000100110011011001110101100011  to  address 011111111 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 0+01000100110011011001110101100011 from address 011111111 (from port 0) during cycle 20 (200ns - 210ns)
*	Writing 0+01100001100100100111010101011001  to  address 000000000 (from port 0) during cycle 21 (210ns - 220ns)
*	Reading 0+01100001100100100111010101011001 from address 000000000 (from port 0) during cycle 23 (230ns - 240ns)
*	Reading 0+01000100110011011001110101100011 from address 011111111 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 0+01100001100100100111010101011001 from address 000000000 (from port 0) during cycle 25 (250ns - 260ns)
*	Reading 0+01000100110011011001110101100011 from address 011111111 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 0+01100001100100100111010101011001 from address 000000000 (from port 0) during cycle 27 (270ns - 280ns)
*	Reading 0+01100001100100100111010101011001 from address 000000000 (from port 0) during cycle 28 (280ns - 290ns)
*	Writing 0+11111010101001100000000100111011  to  address 000000000 (from port 0) during cycle 29 (290ns - 300ns)
*	Reading 0+01000100110011011001110101100011 from address 011111111 (from port 0) during cycle 33 (330ns - 340ns)
*	Reading 0+11111010101001100000000100111011 from address 000000000 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 0+01000100110011011001110101100011 from address 011111111 (from port 0) during cycle 36 (360ns - 370ns)
*	Reading 0+01000100110011011001110101100011 from address 011111111 (from port 0) during cycle 37 (370ns - 380ns)
*	Writing 0+01100101101010110101010001000111  to  address 000000000 (from port 0) during cycle 39 (390ns - 400ns)
*	Writing 0+11111101101010000010110010010110  to  address 011111111 (from port 0) during cycle 40 (400ns - 410ns)
*	Writing 0+10000101101110101011011011010101  to  address 011111111 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 43 (430ns - 440ns)
*	Reading 0+10000101101110101011011011010101 from address 011111111 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 45 (450ns - 460ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 47 (470ns - 480ns)
*	Reading 0+10000101101110101011011011010101 from address 011111111 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 49 (490ns - 500ns)
*	Writing 0+11100101100111011010000000111000  to  address 011111111 (from port 0) during cycle 50 (500ns - 510ns)
*	Writing 0+00010011111000000000011111000111  to  address 011111111 (from port 0) during cycle 51 (510ns - 520ns)
*	Writing 0+00000001001100100110000001010001  to  address 011111111 (from port 0) during cycle 52 (520ns - 530ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 53 (530ns - 540ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 0+00000001001100100110000001010001 from address 011111111 (from port 0) during cycle 55 (550ns - 560ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 56 (560ns - 570ns)
*	Writing 0+10001011101001100101110001000000  to  address 011111111 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 58 (580ns - 590ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 0+10001011101001100101110001000000 from address 011111111 (from port 0) during cycle 60 (600ns - 610ns)
*	Reading 0+01100101101010110101010001000111 from address 000000000 (from port 0) during cycle 62 (620ns - 630ns)
*	Writing 0+10011101110001000010111100111101  to  address 000000000 (from port 0) during cycle 64 (640ns - 650ns)
*	Writing 0+10001000011101010010100001011011  to  address 011111111 (from port 0) during cycle 65 (650ns - 660ns)
*	Writing 0+11011111111011000000010111001101  to  address 000000000 (from port 0) during cycle 66 (660ns - 670ns)
*	Writing 0+00001100100111011001001011111101  to  address 000000000 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 69 (690ns - 700ns)
*	Reading 0+00001100100111011001001011111101 from address 000000000 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 0+00001100100111011001001011111101 from address 000000000 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 73 (730ns - 740ns)
*	Reading 0+00001100100111011001001011111101 from address 000000000 (from port 0) during cycle 74 (740ns - 750ns)
*	Writing 0+10001001010011011011100110001100  to  address 000000000 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 76 (760ns - 770ns)
*	Reading 0+10001001010011011011100110001100 from address 000000000 (from port 0) during cycle 77 (770ns - 780ns)
*	Reading 0+10001001010011011011100110001100 from address 000000000 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 0+10001001010011011011100110001100 from address 000000000 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 0+10001001010011011011100110001100 from address 000000000 (from port 0) during cycle 83 (830ns - 840ns)
*	Writing 0+01110000100101111001100110101011  to  address 000000000 (from port 0) during cycle 84 (840ns - 850ns)
*	Writing 0+01101000001101101001001010101111  to  address 000000000 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 0+01101000001101101001001010101111 from address 000000000 (from port 0) during cycle 86 (860ns - 870ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 87 (870ns - 880ns)
*	Writing 0+00100011010101111101111011010010  to  address 000000000 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 0+00100011010101111101111011010010 from address 000000000 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 0+00100011010101111101111011010010 from address 000000000 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 94 (940ns - 950ns)
*	Writing 0+11100001110011110011010110111001  to  address 000000000 (from port 0) during cycle 95 (950ns - 960ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 0+11100001110011110011010110111001 from address 000000000 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 0+11100001110011110011010110111001 from address 000000000 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 0+11100001110011110011010110111001 from address 000000000 (from port 0) during cycle 100 (1000ns - 1010ns)
*	Reading 0+11100001110011110011010110111001 from address 000000000 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 0+11100001110011110011010110111001 from address 000000000 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 0+11100001110011110011010110111001 from address 000000000 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Writing 0+00101101111100111110100110000111  to  address 000000000 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 0+10001000011101010010100001011011 from address 011111111 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Writing 0+00101111001011000001101100000001  to  address 000000000 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 0+00101111001011000001101100000001 from address 000000000 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Writing 0+01110101010101001000001001111011  to  address 000000000 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Writing 0+10011001111100001110110000000000  to  address 011111111 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 0+10011001111100001110110000000000 from address 011111111 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Writing 0+10001110101111110101010111000101  to  address 000000000 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Writing 0+00011100110101100110011011000100  to  address 011111111 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 0+00011100110101100110011011000100 from address 011111111 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 0+00011100110101100110011011000100 from address 011111111 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 0+00011100110101100110011011000100 from address 011111111 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing 0+10011010110101000110111001110110  to  address 011111111 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 0+10011010110101000110111001110110 from address 011111111 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Reading 0+10011010110101000110111001110110 from address 011111111 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Reading 0+10011010110101000110111001110110 from address 011111111 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 0+10011010110101000110111001110110 from address 011111111 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 0+10011010110101000110111001110110 from address 011111111 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Reading 0+10001110101111110101010111000101 from address 000000000 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Writing 0+10111111111111110000101100001111  to  address 011111111 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Reading 0+10111111111111110000101100001111 from address 011111111 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Writing 0+01010110101101101100000001011010  to  address 000000000 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Reading 0+01010110101101101100000001011010 from address 000000000 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Writing 0+10100100111011001110011100101000  to  address 011111111 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Writing 0+01000010111101111111010010000101  to  address 000000000 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 0+01000010111101111111010010000101 from address 000000000 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Reading 0+01000010111101111111010010000101 from address 000000000 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 0+01000010111101111111010010000101 from address 000000000 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Reading 0+01000010111101111111010010000101 from address 000000000 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Writing 0+10010000010000010000101000101001  to  address 000000000 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Writing 0+10110011010000100100011100010111  to  address 000000000 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Writing 0+10110001011101011110101101100101  to  address 000000000 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 0+10110001011101011110101101100101 from address 000000000 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Reading 0+10100100111011001110011100101000 from address 011111111 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Writing 0+10010001110011011100110001110001  to  address 011111111 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 0+10110001011101011110101101100101 from address 000000000 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Reading 0+10110001011101011110101101100101 from address 000000000 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 0+10110001011101011110101101100101 from address 000000000 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Reading 0+10110001011101011110101101100101 from address 000000000 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 0+10110001011101011110101101100101 from address 000000000 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing 0+01100110101001101010111011000001  to  address 000000000 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 0+01100110101001101010111011000001 from address 000000000 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 191 (1910ns - 1920ns)
*	Reading 0+01100110101001101010111011000001 from address 000000000 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Writing 0+00100011010110111010111001101000  to  address 000000000 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Reading 0+10010001110011011100110001110001 from address 011111111 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Reading 0+00100011010110111010111001101000 from address 000000000 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Writing 0+10100100111101111111000011101101  to  address 011111111 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 0+00100011010110111010111001101000 from address 000000000 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 3.3v 29.495n 3.3v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 3.3v 29.495n 3.3v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 3.3v 689.495n 3.3v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 1), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 3.3v 519.495n 3.3v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 3.3v 649.495n 3.3v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 3.3v 899.495n 3.3v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 3.3v 1079.495n 3.3v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 3.3v 1109.495n 3.3v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 3.3v 1959.495n 3.3v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 3.3v 29.495n 3.3v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 3.3v 69.495n 3.3v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 3.3v 219.495n 3.3v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 3.3v 399.495n 3.3v 399.505n 3.3v 409.495n 3.3v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 3.3v 849.495n 3.3v 849.505n 3.3v 859.495n 3.3v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 3.3v 1129.495n 3.3v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 3.3v 1449.495n 3.3v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 3.3v 1489.495n 3.3v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 3.3v 1879.495n 3.3v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 1), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 3.3v 129.495n 3.3v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 3.3v 299.495n 3.3v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 3.3v 509.495n 3.3v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 3.3v 649.495n 3.3v 649.505n 3.3v 659.495n 3.3v 659.505n 3.3v 669.495n 3.3v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 3.3v 759.495n 3.3v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 3.3v 959.495n 3.3v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 3.3v 1159.495n 3.3v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 3.3v 1599.495n 3.3v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 3.3v 1629.495n 3.3v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 3.3v 1659.495n 3.3v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_32  din0_32  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 1), (150, 1), (160, 1), (170, 0), (180, 1), (190, 1), (200, 1), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 1), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 0), (400, 1), (410, 1), (420, 0), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 1), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 1), (740, 0), (750, 0), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 0), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 0), (1490, 0), (1500, 0), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 3.3v 19.495n 3.3v 19.505n 0.0v 29.495n 0.0v 29.505n 3.3v 39.495n 3.3v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 3.3v 69.495n 3.3v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 3.3v 109.495n 3.3v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 3.3v 149.495n 3.3v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 3.3v 189.495n 3.3v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 3.3v 249.495n 3.3v 249.505n 0.0v 259.495n 0.0v 259.505n 3.3v 269.495n 3.3v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 3.3v 339.495n 3.3v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 3.3v 409.495n 3.3v 409.505n 3.3v 419.495n 3.3v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 3.3v 449.495n 3.3v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 3.3v 489.495n 3.3v 489.505n 0.0v 499.495n 0.0v 499.505n 3.3v 509.495n 3.3v 509.505n 3.3v 519.495n 3.3v 519.505n 3.3v 529.495n 3.3v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 3.3v 559.495n 3.3v 559.505n 0.0v 569.495n 0.0v 569.505n 3.3v 579.495n 3.3v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 3.3v 659.495n 3.3v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 0.0v 709.495n 0.0v 709.505n 3.3v 719.495n 3.3v 719.505n 0.0v 729.495n 0.0v 729.505n 3.3v 739.495n 3.3v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 3.3v 819.495n 3.3v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 0.0v 919.495n 0.0v 919.505n 3.3v 929.495n 3.3v 929.505n 0.0v 939.495n 0.0v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 3.3v 999.495n 3.3v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 3.3v 1139.495n 3.3v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 3.3v 1179.495n 3.3v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 3.3v 1309.495n 3.3v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 3.3v 1419.495n 3.3v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 3.3v 1469.495n 3.3v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 3.3v 1719.495n 3.3v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 3.3v 1999.495n 3.3v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_8  a0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 0), (180, 0), (190, 1), (200, 0), (210, 0), (220, 1), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 1), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 3.3v 9.495n 3.3v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 3.3v 169.495n 3.3v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 3.3v 199.495n 3.3v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 3.3v 229.495n 3.3v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 3.3v 359.495n 3.3v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 3.3v 619.495n 3.3v 619.505n 0.0v 629.495n 0.0v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 1), (140, 0), (150, 1), (160, 1), (170, 1), (180, 0), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 0), (400, 0), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 0), (650, 0), (660, 0), (670, 1), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 1), (1170, 0), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 0), (1450, 1), (1460, 0), (1470, 1), (1480, 0), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 3.3v 9.495n 3.3v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 3.3v 49.495n 3.3v 49.505n 3.3v 59.495n 3.3v 59.505n 0.0v 69.495n 0.0v 69.505n 3.3v 79.495n 3.3v 79.505n 3.3v 89.495n 3.3v 89.505n 3.3v 99.495n 3.3v 99.505n 3.3v 109.495n 3.3v 109.505n 3.3v 119.495n 3.3v 119.505n 0.0v 129.495n 0.0v 129.505n 3.3v 139.495n 3.3v 139.505n 0.0v 149.495n 0.0v 149.505n 3.3v 159.495n 3.3v 159.505n 3.3v 169.495n 3.3v 169.505n 3.3v 179.495n 3.3v 179.505n 0.0v 189.495n 0.0v 189.505n 3.3v 199.495n 3.3v 199.505n 3.3v 209.495n 3.3v 209.505n 0.0v 219.495n 0.0v 219.505n 3.3v 229.495n 3.3v 229.505n 3.3v 239.495n 3.3v 239.505n 3.3v 249.495n 3.3v 249.505n 3.3v 259.495n 3.3v 259.505n 3.3v 269.495n 3.3v 269.505n 3.3v 279.495n 3.3v 279.505n 3.3v 289.495n 3.3v 289.505n 0.0v 299.495n 0.0v 299.505n 3.3v 309.495n 3.3v 309.505n 3.3v 319.495n 3.3v 319.505n 3.3v 329.495n 3.3v 329.505n 3.3v 339.495n 3.3v 339.505n 3.3v 349.495n 3.3v 349.505n 3.3v 359.495n 3.3v 359.505n 3.3v 369.495n 3.3v 369.505n 3.3v 379.495n 3.3v 379.505n 3.3v 389.495n 3.3v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 3.3v 429.495n 3.3v 429.505n 3.3v 439.495n 3.3v 439.505n 3.3v 449.495n 3.3v 449.505n 3.3v 459.495n 3.3v 459.505n 3.3v 469.495n 3.3v 469.505n 3.3v 479.495n 3.3v 479.505n 3.3v 489.495n 3.3v 489.505n 3.3v 499.495n 3.3v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 3.3v 539.495n 3.3v 539.505n 3.3v 549.495n 3.3v 549.505n 3.3v 559.495n 3.3v 559.505n 3.3v 569.495n 3.3v 569.505n 0.0v 579.495n 0.0v 579.505n 3.3v 589.495n 3.3v 589.505n 3.3v 599.495n 3.3v 599.505n 3.3v 609.495n 3.3v 609.505n 3.3v 619.495n 3.3v 619.505n 3.3v 629.495n 3.3v 629.505n 3.3v 639.495n 3.3v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 3.3v 679.495n 3.3v 679.505n 0.0v 689.495n 0.0v 689.505n 3.3v 699.495n 3.3v 699.505n 3.3v 709.495n 3.3v 709.505n 3.3v 719.495n 3.3v 719.505n 3.3v 729.495n 3.3v 729.505n 3.3v 739.495n 3.3v 739.505n 3.3v 749.495n 3.3v 749.505n 0.0v 759.495n 0.0v 759.505n 3.3v 769.495n 3.3v 769.505n 3.3v 779.495n 3.3v 779.505n 3.3v 789.495n 3.3v 789.505n 3.3v 799.495n 3.3v 799.505n 3.3v 809.495n 3.3v 809.505n 3.3v 819.495n 3.3v 819.505n 3.3v 829.495n 3.3v 829.505n 3.3v 839.495n 3.3v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 3.3v 869.495n 3.3v 869.505n 3.3v 879.495n 3.3v 879.505n 3.3v 889.495n 3.3v 889.505n 0.0v 899.495n 0.0v 899.505n 3.3v 909.495n 3.3v 909.505n 3.3v 919.495n 3.3v 919.505n 3.3v 929.495n 3.3v 929.505n 3.3v 939.495n 3.3v 939.505n 3.3v 949.495n 3.3v 949.505n 0.0v 959.495n 0.0v 959.505n 3.3v 969.495n 3.3v 969.505n 3.3v 979.495n 3.3v 979.505n 3.3v 989.495n 3.3v 989.505n 3.3v 999.495n 3.3v 999.505n 3.3v 1009.495n 3.3v 1009.505n 3.3v 1019.495n 3.3v 1019.505n 3.3v 1029.495n 3.3v 1029.505n 3.3v 1039.495n 3.3v 1039.505n 3.3v 1049.495n 3.3v 1049.505n 3.3v 1059.495n 3.3v 1059.505n 3.3v 1069.495n 3.3v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 3.3v 1089.495n 3.3v 1089.505n 3.3v 1099.495n 3.3v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 3.3v 1119.495n 3.3v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 3.3v 1149.495n 3.3v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 3.3v 1169.495n 3.3v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 3.3v 1189.495n 3.3v 1189.505n 3.3v 1199.495n 3.3v 1199.505n 3.3v 1209.495n 3.3v 1209.505n 3.3v 1219.495n 3.3v 1219.505n 3.3v 1229.495n 3.3v 1229.505n 3.3v 1239.495n 3.3v 1239.505n 3.3v 1249.495n 3.3v 1249.505n 3.3v 1259.495n 3.3v 1259.505n 3.3v 1269.495n 3.3v 1269.505n 3.3v 1279.495n 3.3v 1279.505n 3.3v 1289.495n 3.3v 1289.505n 3.3v 1299.495n 3.3v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 3.3v 1319.495n 3.3v 1319.505n 3.3v 1329.495n 3.3v 1329.505n 3.3v 1339.495n 3.3v 1339.505n 3.3v 1349.495n 3.3v 1349.505n 3.3v 1359.495n 3.3v 1359.505n 3.3v 1369.495n 3.3v 1369.505n 3.3v 1379.495n 3.3v 1379.505n 3.3v 1389.495n 3.3v 1389.505n 3.3v 1399.495n 3.3v 1399.505n 3.3v 1409.495n 3.3v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 3.3v 1429.495n 3.3v 1429.505n 3.3v 1439.495n 3.3v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 3.3v 1459.495n 3.3v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 3.3v 1479.495n 3.3v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 3.3v 1499.495n 3.3v 1499.505n 3.3v 1509.495n 3.3v 1509.505n 3.3v 1519.495n 3.3v 1519.505n 3.3v 1529.495n 3.3v 1529.505n 3.3v 1539.495n 3.3v 1539.505n 3.3v 1549.495n 3.3v 1549.505n 3.3v 1559.495n 3.3v 1559.505n 3.3v 1569.495n 3.3v 1569.505n 3.3v 1579.495n 3.3v 1579.505n 3.3v 1589.495n 3.3v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 3.3v 1609.495n 3.3v 1609.505n 3.3v 1619.495n 3.3v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 3.3v 1639.495n 3.3v 1639.505n 3.3v 1649.495n 3.3v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 3.3v 1669.495n 3.3v 1669.505n 3.3v 1679.495n 3.3v 1679.505n 3.3v 1689.495n 3.3v 1689.505n 3.3v 1699.495n 3.3v 1699.505n 3.3v 1709.495n 3.3v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 3.3v 1729.495n 3.3v 1729.505n 3.3v 1739.495n 3.3v 1739.505n 3.3v 1749.495n 3.3v 1749.505n 3.3v 1759.495n 3.3v 1759.505n 3.3v 1769.495n 3.3v 1769.505n 3.3v 1779.495n 3.3v 1779.505n 3.3v 1789.495n 3.3v 1789.505n 3.3v 1799.495n 3.3v 1799.505n 3.3v 1809.495n 3.3v 1809.505n 3.3v 1819.495n 3.3v 1819.505n 3.3v 1829.495n 3.3v 1829.505n 3.3v 1839.495n 3.3v 1839.505n 3.3v 1849.495n 3.3v 1849.505n 3.3v 1859.495n 3.3v 1859.505n 3.3v 1869.495n 3.3v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 3.3v 1889.495n 3.3v 1889.505n 3.3v 1899.495n 3.3v 1899.505n 3.3v 1909.495n 3.3v 1909.505n 3.3v 1919.495n 3.3v 1919.505n 3.3v 1929.495n 3.3v 1929.505n 3.3v 1939.495n 3.3v 1939.505n 3.3v 1949.495n 3.3v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 3.3v 1969.495n 3.3v 1969.505n 3.3v 1979.495n 3.3v 1979.505n 3.3v 1989.495n 3.3v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 3.3v 2009.495n 3.3v 2009.505n 3.3v 2019.495n 3.3v 2019.505n 3.3v 2029.495n 3.3v 2029.505n 3.3v 2039.495n 3.3v 2039.505n 3.3v 2049.495n 3.3v 2049.505n 3.3v )

* Generation of spare enable signals
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
VSPARE_WEN0_0  SPARE_WEN0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 3.3 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 vdout0_0ck4 = 3.3 time = 50
* CHECK dout0_1 vdout0_1ck4 = 3.3 time = 50
* CHECK dout0_2 vdout0_2ck4 = 0 time = 50
* CHECK dout0_3 vdout0_3ck4 = 0 time = 50
* CHECK dout0_4 vdout0_4ck4 = 0 time = 50
* CHECK dout0_5 vdout0_5ck4 = 3.3 time = 50
* CHECK dout0_6 vdout0_6ck4 = 0 time = 50
* CHECK dout0_7 vdout0_7ck4 = 3.3 time = 50
* CHECK dout0_8 vdout0_8ck4 = 0 time = 50
* CHECK dout0_9 vdout0_9ck4 = 0 time = 50
* CHECK dout0_10 vdout0_10ck4 = 3.3 time = 50
* CHECK dout0_11 vdout0_11ck4 = 0 time = 50
* CHECK dout0_12 vdout0_12ck4 = 0 time = 50
* CHECK dout0_13 vdout0_13ck4 = 3.3 time = 50
* CHECK dout0_14 vdout0_14ck4 = 0 time = 50
* CHECK dout0_15 vdout0_15ck4 = 0 time = 50
* CHECK dout0_16 vdout0_16ck4 = 0 time = 50
* CHECK dout0_17 vdout0_17ck4 = 0 time = 50
* CHECK dout0_18 vdout0_18ck4 = 0 time = 50
* CHECK dout0_19 vdout0_19ck4 = 0 time = 50
* CHECK dout0_20 vdout0_20ck4 = 0 time = 50
* CHECK dout0_21 vdout0_21ck4 = 3.3 time = 50
* CHECK dout0_22 vdout0_22ck4 = 3.3 time = 50
* CHECK dout0_23 vdout0_23ck4 = 0 time = 50
* CHECK dout0_24 vdout0_24ck4 = 0 time = 50
* CHECK dout0_25 vdout0_25ck4 = 0 time = 50
* CHECK dout0_26 vdout0_26ck4 = 3.3 time = 50
* CHECK dout0_27 vdout0_27ck4 = 3.3 time = 50
* CHECK dout0_28 vdout0_28ck4 = 3.3 time = 50
* CHECK dout0_29 vdout0_29ck4 = 3.3 time = 50
* CHECK dout0_30 vdout0_30ck4 = 3.3 time = 50
* CHECK dout0_31 vdout0_31ck4 = 0 time = 50
* CHECK dout0_32 vdout0_32ck4 = 0 time = 50
* CHECK dout0_0 vdout0_0ck7 = 3.3 time = 80
* CHECK dout0_1 vdout0_1ck7 = 3.3 time = 80
* CHECK dout0_2 vdout0_2ck7 = 0 time = 80
* CHECK dout0_3 vdout0_3ck7 = 0 time = 80
* CHECK dout0_4 vdout0_4ck7 = 0 time = 80
* CHECK dout0_5 vdout0_5ck7 = 3.3 time = 80
* CHECK dout0_6 vdout0_6ck7 = 0 time = 80
* CHECK dout0_7 vdout0_7ck7 = 3.3 time = 80
* CHECK dout0_8 vdout0_8ck7 = 0 time = 80
* CHECK dout0_9 vdout0_9ck7 = 0 time = 80
* CHECK dout0_10 vdout0_10ck7 = 3.3 time = 80
* CHECK dout0_11 vdout0_11ck7 = 0 time = 80
* CHECK dout0_12 vdout0_12ck7 = 0 time = 80
* CHECK dout0_13 vdout0_13ck7 = 3.3 time = 80
* CHECK dout0_14 vdout0_14ck7 = 0 time = 80
* CHECK dout0_15 vdout0_15ck7 = 0 time = 80
* CHECK dout0_16 vdout0_16ck7 = 0 time = 80
* CHECK dout0_17 vdout0_17ck7 = 0 time = 80
* CHECK dout0_18 vdout0_18ck7 = 0 time = 80
* CHECK dout0_19 vdout0_19ck7 = 0 time = 80
* CHECK dout0_20 vdout0_20ck7 = 0 time = 80
* CHECK dout0_21 vdout0_21ck7 = 3.3 time = 80
* CHECK dout0_22 vdout0_22ck7 = 3.3 time = 80
* CHECK dout0_23 vdout0_23ck7 = 0 time = 80
* CHECK dout0_24 vdout0_24ck7 = 0 time = 80
* CHECK dout0_25 vdout0_25ck7 = 0 time = 80
* CHECK dout0_26 vdout0_26ck7 = 3.3 time = 80
* CHECK dout0_27 vdout0_27ck7 = 3.3 time = 80
* CHECK dout0_28 vdout0_28ck7 = 3.3 time = 80
* CHECK dout0_29 vdout0_29ck7 = 3.3 time = 80
* CHECK dout0_30 vdout0_30ck7 = 3.3 time = 80
* CHECK dout0_31 vdout0_31ck7 = 0 time = 80
* CHECK dout0_32 vdout0_32ck7 = 0 time = 80
* CHECK dout0_0 vdout0_0ck8 = 3.3 time = 90
* CHECK dout0_1 vdout0_1ck8 = 3.3 time = 90
* CHECK dout0_2 vdout0_2ck8 = 0 time = 90
* CHECK dout0_3 vdout0_3ck8 = 0 time = 90
* CHECK dout0_4 vdout0_4ck8 = 0 time = 90
* CHECK dout0_5 vdout0_5ck8 = 3.3 time = 90
* CHECK dout0_6 vdout0_6ck8 = 0 time = 90
* CHECK dout0_7 vdout0_7ck8 = 3.3 time = 90
* CHECK dout0_8 vdout0_8ck8 = 0 time = 90
* CHECK dout0_9 vdout0_9ck8 = 0 time = 90
* CHECK dout0_10 vdout0_10ck8 = 3.3 time = 90
* CHECK dout0_11 vdout0_11ck8 = 0 time = 90
* CHECK dout0_12 vdout0_12ck8 = 0 time = 90
* CHECK dout0_13 vdout0_13ck8 = 3.3 time = 90
* CHECK dout0_14 vdout0_14ck8 = 0 time = 90
* CHECK dout0_15 vdout0_15ck8 = 0 time = 90
* CHECK dout0_16 vdout0_16ck8 = 0 time = 90
* CHECK dout0_17 vdout0_17ck8 = 0 time = 90
* CHECK dout0_18 vdout0_18ck8 = 0 time = 90
* CHECK dout0_19 vdout0_19ck8 = 0 time = 90
* CHECK dout0_20 vdout0_20ck8 = 0 time = 90
* CHECK dout0_21 vdout0_21ck8 = 3.3 time = 90
* CHECK dout0_22 vdout0_22ck8 = 3.3 time = 90
* CHECK dout0_23 vdout0_23ck8 = 0 time = 90
* CHECK dout0_24 vdout0_24ck8 = 0 time = 90
* CHECK dout0_25 vdout0_25ck8 = 0 time = 90
* CHECK dout0_26 vdout0_26ck8 = 3.3 time = 90
* CHECK dout0_27 vdout0_27ck8 = 3.3 time = 90
* CHECK dout0_28 vdout0_28ck8 = 3.3 time = 90
* CHECK dout0_29 vdout0_29ck8 = 3.3 time = 90
* CHECK dout0_30 vdout0_30ck8 = 3.3 time = 90
* CHECK dout0_31 vdout0_31ck8 = 0 time = 90
* CHECK dout0_32 vdout0_32ck8 = 0 time = 90
* CHECK dout0_0 vdout0_0ck9 = 3.3 time = 100
* CHECK dout0_1 vdout0_1ck9 = 3.3 time = 100
* CHECK dout0_2 vdout0_2ck9 = 0 time = 100
* CHECK dout0_3 vdout0_3ck9 = 0 time = 100
* CHECK dout0_4 vdout0_4ck9 = 0 time = 100
* CHECK dout0_5 vdout0_5ck9 = 3.3 time = 100
* CHECK dout0_6 vdout0_6ck9 = 0 time = 100
* CHECK dout0_7 vdout0_7ck9 = 3.3 time = 100
* CHECK dout0_8 vdout0_8ck9 = 0 time = 100
* CHECK dout0_9 vdout0_9ck9 = 0 time = 100
* CHECK dout0_10 vdout0_10ck9 = 3.3 time = 100
* CHECK dout0_11 vdout0_11ck9 = 0 time = 100
* CHECK dout0_12 vdout0_12ck9 = 0 time = 100
* CHECK dout0_13 vdout0_13ck9 = 3.3 time = 100
* CHECK dout0_14 vdout0_14ck9 = 0 time = 100
* CHECK dout0_15 vdout0_15ck9 = 0 time = 100
* CHECK dout0_16 vdout0_16ck9 = 0 time = 100
* CHECK dout0_17 vdout0_17ck9 = 0 time = 100
* CHECK dout0_18 vdout0_18ck9 = 0 time = 100
* CHECK dout0_19 vdout0_19ck9 = 0 time = 100
* CHECK dout0_20 vdout0_20ck9 = 0 time = 100
* CHECK dout0_21 vdout0_21ck9 = 3.3 time = 100
* CHECK dout0_22 vdout0_22ck9 = 3.3 time = 100
* CHECK dout0_23 vdout0_23ck9 = 0 time = 100
* CHECK dout0_24 vdout0_24ck9 = 0 time = 100
* CHECK dout0_25 vdout0_25ck9 = 0 time = 100
* CHECK dout0_26 vdout0_26ck9 = 3.3 time = 100
* CHECK dout0_27 vdout0_27ck9 = 3.3 time = 100
* CHECK dout0_28 vdout0_28ck9 = 3.3 time = 100
* CHECK dout0_29 vdout0_29ck9 = 3.3 time = 100
* CHECK dout0_30 vdout0_30ck9 = 3.3 time = 100
* CHECK dout0_31 vdout0_31ck9 = 0 time = 100
* CHECK dout0_32 vdout0_32ck9 = 0 time = 100
* CHECK dout0_0 vdout0_0ck10 = 3.3 time = 110
* CHECK dout0_1 vdout0_1ck10 = 3.3 time = 110
* CHECK dout0_2 vdout0_2ck10 = 3.3 time = 110
* CHECK dout0_3 vdout0_3ck10 = 0 time = 110
* CHECK dout0_4 vdout0_4ck10 = 0 time = 110
* CHECK dout0_5 vdout0_5ck10 = 0 time = 110
* CHECK dout0_6 vdout0_6ck10 = 0 time = 110
* CHECK dout0_7 vdout0_7ck10 = 3.3 time = 110
* CHECK dout0_8 vdout0_8ck10 = 0 time = 110
* CHECK dout0_9 vdout0_9ck10 = 0 time = 110
* CHECK dout0_10 vdout0_10ck10 = 3.3 time = 110
* CHECK dout0_11 vdout0_11ck10 = 3.3 time = 110
* CHECK dout0_12 vdout0_12ck10 = 3.3 time = 110
* CHECK dout0_13 vdout0_13ck10 = 3.3 time = 110
* CHECK dout0_14 vdout0_14ck10 = 0 time = 110
* CHECK dout0_15 vdout0_15ck10 = 0 time = 110
* CHECK dout0_16 vdout0_16ck10 = 0 time = 110
* CHECK dout0_17 vdout0_17ck10 = 3.3 time = 110
* CHECK dout0_18 vdout0_18ck10 = 3.3 time = 110
* CHECK dout0_19 vdout0_19ck10 = 0 time = 110
* CHECK dout0_20 vdout0_20ck10 = 3.3 time = 110
* CHECK dout0_21 vdout0_21ck10 = 0 time = 110
* CHECK dout0_22 vdout0_22ck10 = 3.3 time = 110
* CHECK dout0_23 vdout0_23ck10 = 3.3 time = 110
* CHECK dout0_24 vdout0_24ck10 = 0 time = 110
* CHECK dout0_25 vdout0_25ck10 = 3.3 time = 110
* CHECK dout0_26 vdout0_26ck10 = 0 time = 110
* CHECK dout0_27 vdout0_27ck10 = 3.3 time = 110
* CHECK dout0_28 vdout0_28ck10 = 0 time = 110
* CHECK dout0_29 vdout0_29ck10 = 0 time = 110
* CHECK dout0_30 vdout0_30ck10 = 3.3 time = 110
* CHECK dout0_31 vdout0_31ck10 = 0 time = 110
* CHECK dout0_32 vdout0_32ck10 = 0 time = 110
* CHECK dout0_0 vdout0_0ck11 = 3.3 time = 120
* CHECK dout0_1 vdout0_1ck11 = 3.3 time = 120
* CHECK dout0_2 vdout0_2ck11 = 0 time = 120
* CHECK dout0_3 vdout0_3ck11 = 0 time = 120
* CHECK dout0_4 vdout0_4ck11 = 0 time = 120
* CHECK dout0_5 vdout0_5ck11 = 3.3 time = 120
* CHECK dout0_6 vdout0_6ck11 = 0 time = 120
* CHECK dout0_7 vdout0_7ck11 = 3.3 time = 120
* CHECK dout0_8 vdout0_8ck11 = 0 time = 120
* CHECK dout0_9 vdout0_9ck11 = 0 time = 120
* CHECK dout0_10 vdout0_10ck11 = 3.3 time = 120
* CHECK dout0_11 vdout0_11ck11 = 0 time = 120
* CHECK dout0_12 vdout0_12ck11 = 0 time = 120
* CHECK dout0_13 vdout0_13ck11 = 3.3 time = 120
* CHECK dout0_14 vdout0_14ck11 = 0 time = 120
* CHECK dout0_15 vdout0_15ck11 = 0 time = 120
* CHECK dout0_16 vdout0_16ck11 = 0 time = 120
* CHECK dout0_17 vdout0_17ck11 = 0 time = 120
* CHECK dout0_18 vdout0_18ck11 = 0 time = 120
* CHECK dout0_19 vdout0_19ck11 = 0 time = 120
* CHECK dout0_20 vdout0_20ck11 = 0 time = 120
* CHECK dout0_21 vdout0_21ck11 = 3.3 time = 120
* CHECK dout0_22 vdout0_22ck11 = 3.3 time = 120
* CHECK dout0_23 vdout0_23ck11 = 0 time = 120
* CHECK dout0_24 vdout0_24ck11 = 0 time = 120
* CHECK dout0_25 vdout0_25ck11 = 0 time = 120
* CHECK dout0_26 vdout0_26ck11 = 3.3 time = 120
* CHECK dout0_27 vdout0_27ck11 = 3.3 time = 120
* CHECK dout0_28 vdout0_28ck11 = 3.3 time = 120
* CHECK dout0_29 vdout0_29ck11 = 3.3 time = 120
* CHECK dout0_30 vdout0_30ck11 = 3.3 time = 120
* CHECK dout0_31 vdout0_31ck11 = 0 time = 120
* CHECK dout0_32 vdout0_32ck11 = 0 time = 120
* CHECK dout0_0 vdout0_0ck13 = 0 time = 140
* CHECK dout0_1 vdout0_1ck13 = 3.3 time = 140
* CHECK dout0_2 vdout0_2ck13 = 3.3 time = 140
* CHECK dout0_3 vdout0_3ck13 = 0 time = 140
* CHECK dout0_4 vdout0_4ck13 = 3.3 time = 140
* CHECK dout0_5 vdout0_5ck13 = 3.3 time = 140
* CHECK dout0_6 vdout0_6ck13 = 0 time = 140
* CHECK dout0_7 vdout0_7ck13 = 0 time = 140
* CHECK dout0_8 vdout0_8ck13 = 3.3 time = 140
* CHECK dout0_9 vdout0_9ck13 = 3.3 time = 140
* CHECK dout0_10 vdout0_10ck13 = 0 time = 140
* CHECK dout0_11 vdout0_11ck13 = 0 time = 140
* CHECK dout0_12 vdout0_12ck13 = 0 time = 140
* CHECK dout0_13 vdout0_13ck13 = 3.3 time = 140
* CHECK dout0_14 vdout0_14ck13 = 3.3 time = 140
* CHECK dout0_15 vdout0_15ck13 = 3.3 time = 140
* CHECK dout0_16 vdout0_16ck13 = 0 time = 140
* CHECK dout0_17 vdout0_17ck13 = 0 time = 140
* CHECK dout0_18 vdout0_18ck13 = 0 time = 140
* CHECK dout0_19 vdout0_19ck13 = 0 time = 140
* CHECK dout0_20 vdout0_20ck13 = 0 time = 140
* CHECK dout0_21 vdout0_21ck13 = 3.3 time = 140
* CHECK dout0_22 vdout0_22ck13 = 3.3 time = 140
* CHECK dout0_23 vdout0_23ck13 = 3.3 time = 140
* CHECK dout0_24 vdout0_24ck13 = 0 time = 140
* CHECK dout0_25 vdout0_25ck13 = 0 time = 140
* CHECK dout0_26 vdout0_26ck13 = 0 time = 140
* CHECK dout0_27 vdout0_27ck13 = 3.3 time = 140
* CHECK dout0_28 vdout0_28ck13 = 0 time = 140
* CHECK dout0_29 vdout0_29ck13 = 0 time = 140
* CHECK dout0_30 vdout0_30ck13 = 0 time = 140
* CHECK dout0_31 vdout0_31ck13 = 3.3 time = 140
* CHECK dout0_32 vdout0_32ck13 = 0 time = 140
* CHECK dout0_0 vdout0_0ck15 = 3.3 time = 160
* CHECK dout0_1 vdout0_1ck15 = 3.3 time = 160
* CHECK dout0_2 vdout0_2ck15 = 0 time = 160
* CHECK dout0_3 vdout0_3ck15 = 3.3 time = 160
* CHECK dout0_4 vdout0_4ck15 = 0 time = 160
* CHECK dout0_5 vdout0_5ck15 = 0 time = 160
* CHECK dout0_6 vdout0_6ck15 = 3.3 time = 160
* CHECK dout0_7 vdout0_7ck15 = 3.3 time = 160
* CHECK dout0_8 vdout0_8ck15 = 3.3 time = 160
* CHECK dout0_9 vdout0_9ck15 = 3.3 time = 160
* CHECK dout0_10 vdout0_10ck15 = 0 time = 160
* CHECK dout0_11 vdout0_11ck15 = 0 time = 160
* CHECK dout0_12 vdout0_12ck15 = 3.3 time = 160
* CHECK dout0_13 vdout0_13ck15 = 3.3 time = 160
* CHECK dout0_14 vdout0_14ck15 = 3.3 time = 160
* CHECK dout0_15 vdout0_15ck15 = 0 time = 160
* CHECK dout0_16 vdout0_16ck15 = 3.3 time = 160
* CHECK dout0_17 vdout0_17ck15 = 3.3 time = 160
* CHECK dout0_18 vdout0_18ck15 = 3.3 time = 160
* CHECK dout0_19 vdout0_19ck15 = 0 time = 160
* CHECK dout0_20 vdout0_20ck15 = 3.3 time = 160
* CHECK dout0_21 vdout0_21ck15 = 3.3 time = 160
* CHECK dout0_22 vdout0_22ck15 = 0 time = 160
* CHECK dout0_23 vdout0_23ck15 = 3.3 time = 160
* CHECK dout0_24 vdout0_24ck15 = 0 time = 160
* CHECK dout0_25 vdout0_25ck15 = 0 time = 160
* CHECK dout0_26 vdout0_26ck15 = 3.3 time = 160
* CHECK dout0_27 vdout0_27ck15 = 0 time = 160
* CHECK dout0_28 vdout0_28ck15 = 3.3 time = 160
* CHECK dout0_29 vdout0_29ck15 = 3.3 time = 160
* CHECK dout0_30 vdout0_30ck15 = 0 time = 160
* CHECK dout0_31 vdout0_31ck15 = 0 time = 160
* CHECK dout0_32 vdout0_32ck15 = 0 time = 160
* CHECK dout0_0 vdout0_0ck17 = 0 time = 180
* CHECK dout0_1 vdout0_1ck17 = 3.3 time = 180
* CHECK dout0_2 vdout0_2ck17 = 3.3 time = 180
* CHECK dout0_3 vdout0_3ck17 = 0 time = 180
* CHECK dout0_4 vdout0_4ck17 = 3.3 time = 180
* CHECK dout0_5 vdout0_5ck17 = 3.3 time = 180
* CHECK dout0_6 vdout0_6ck17 = 0 time = 180
* CHECK dout0_7 vdout0_7ck17 = 0 time = 180
* CHECK dout0_8 vdout0_8ck17 = 3.3 time = 180
* CHECK dout0_9 vdout0_9ck17 = 3.3 time = 180
* CHECK dout0_10 vdout0_10ck17 = 0 time = 180
* CHECK dout0_11 vdout0_11ck17 = 0 time = 180
* CHECK dout0_12 vdout0_12ck17 = 0 time = 180
* CHECK dout0_13 vdout0_13ck17 = 3.3 time = 180
* CHECK dout0_14 vdout0_14ck17 = 3.3 time = 180
* CHECK dout0_15 vdout0_15ck17 = 3.3 time = 180
* CHECK dout0_16 vdout0_16ck17 = 0 time = 180
* CHECK dout0_17 vdout0_17ck17 = 0 time = 180
* CHECK dout0_18 vdout0_18ck17 = 0 time = 180
* CHECK dout0_19 vdout0_19ck17 = 0 time = 180
* CHECK dout0_20 vdout0_20ck17 = 0 time = 180
* CHECK dout0_21 vdout0_21ck17 = 3.3 time = 180
* CHECK dout0_22 vdout0_22ck17 = 3.3 time = 180
* CHECK dout0_23 vdout0_23ck17 = 3.3 time = 180
* CHECK dout0_24 vdout0_24ck17 = 0 time = 180
* CHECK dout0_25 vdout0_25ck17 = 0 time = 180
* CHECK dout0_26 vdout0_26ck17 = 0 time = 180
* CHECK dout0_27 vdout0_27ck17 = 3.3 time = 180
* CHECK dout0_28 vdout0_28ck17 = 0 time = 180
* CHECK dout0_29 vdout0_29ck17 = 0 time = 180
* CHECK dout0_30 vdout0_30ck17 = 0 time = 180
* CHECK dout0_31 vdout0_31ck17 = 3.3 time = 180
* CHECK dout0_32 vdout0_32ck17 = 0 time = 180
* CHECK dout0_0 vdout0_0ck20 = 3.3 time = 210
* CHECK dout0_1 vdout0_1ck20 = 3.3 time = 210
* CHECK dout0_2 vdout0_2ck20 = 0 time = 210
* CHECK dout0_3 vdout0_3ck20 = 0 time = 210
* CHECK dout0_4 vdout0_4ck20 = 0 time = 210
* CHECK dout0_5 vdout0_5ck20 = 3.3 time = 210
* CHECK dout0_6 vdout0_6ck20 = 3.3 time = 210
* CHECK dout0_7 vdout0_7ck20 = 0 time = 210
* CHECK dout0_8 vdout0_8ck20 = 3.3 time = 210
* CHECK dout0_9 vdout0_9ck20 = 0 time = 210
* CHECK dout0_10 vdout0_10ck20 = 3.3 time = 210
* CHECK dout0_11 vdout0_11ck20 = 3.3 time = 210
* CHECK dout0_12 vdout0_12ck20 = 3.3 time = 210
* CHECK dout0_13 vdout0_13ck20 = 0 time = 210
* CHECK dout0_14 vdout0_14ck20 = 0 time = 210
* CHECK dout0_15 vdout0_15ck20 = 3.3 time = 210
* CHECK dout0_16 vdout0_16ck20 = 3.3 time = 210
* CHECK dout0_17 vdout0_17ck20 = 0 time = 210
* CHECK dout0_18 vdout0_18ck20 = 3.3 time = 210
* CHECK dout0_19 vdout0_19ck20 = 3.3 time = 210
* CHECK dout0_20 vdout0_20ck20 = 0 time = 210
* CHECK dout0_21 vdout0_21ck20 = 0 time = 210
* CHECK dout0_22 vdout0_22ck20 = 3.3 time = 210
* CHECK dout0_23 vdout0_23ck20 = 3.3 time = 210
* CHECK dout0_24 vdout0_24ck20 = 0 time = 210
* CHECK dout0_25 vdout0_25ck20 = 0 time = 210
* CHECK dout0_26 vdout0_26ck20 = 3.3 time = 210
* CHECK dout0_27 vdout0_27ck20 = 0 time = 210
* CHECK dout0_28 vdout0_28ck20 = 0 time = 210
* CHECK dout0_29 vdout0_29ck20 = 0 time = 210
* CHECK dout0_30 vdout0_30ck20 = 3.3 time = 210
* CHECK dout0_31 vdout0_31ck20 = 0 time = 210
* CHECK dout0_32 vdout0_32ck20 = 0 time = 210
* CHECK dout0_0 vdout0_0ck23 = 3.3 time = 240
* CHECK dout0_1 vdout0_1ck23 = 0 time = 240
* CHECK dout0_2 vdout0_2ck23 = 0 time = 240
* CHECK dout0_3 vdout0_3ck23 = 3.3 time = 240
* CHECK dout0_4 vdout0_4ck23 = 3.3 time = 240
* CHECK dout0_5 vdout0_5ck23 = 0 time = 240
* CHECK dout0_6 vdout0_6ck23 = 3.3 time = 240
* CHECK dout0_7 vdout0_7ck23 = 0 time = 240
* CHECK dout0_8 vdout0_8ck23 = 3.3 time = 240
* CHECK dout0_9 vdout0_9ck23 = 0 time = 240
* CHECK dout0_10 vdout0_10ck23 = 3.3 time = 240
* CHECK dout0_11 vdout0_11ck23 = 0 time = 240
* CHECK dout0_12 vdout0_12ck23 = 3.3 time = 240
* CHECK dout0_13 vdout0_13ck23 = 3.3 time = 240
* CHECK dout0_14 vdout0_14ck23 = 3.3 time = 240
* CHECK dout0_15 vdout0_15ck23 = 0 time = 240
* CHECK dout0_16 vdout0_16ck23 = 0 time = 240
* CHECK dout0_17 vdout0_17ck23 = 3.3 time = 240
* CHECK dout0_18 vdout0_18ck23 = 0 time = 240
* CHECK dout0_19 vdout0_19ck23 = 0 time = 240
* CHECK dout0_20 vdout0_20ck23 = 3.3 time = 240
* CHECK dout0_21 vdout0_21ck23 = 0 time = 240
* CHECK dout0_22 vdout0_22ck23 = 0 time = 240
* CHECK dout0_23 vdout0_23ck23 = 3.3 time = 240
* CHECK dout0_24 vdout0_24ck23 = 3.3 time = 240
* CHECK dout0_25 vdout0_25ck23 = 0 time = 240
* CHECK dout0_26 vdout0_26ck23 = 0 time = 240
* CHECK dout0_27 vdout0_27ck23 = 0 time = 240
* CHECK dout0_28 vdout0_28ck23 = 0 time = 240
* CHECK dout0_29 vdout0_29ck23 = 3.3 time = 240
* CHECK dout0_30 vdout0_30ck23 = 3.3 time = 240
* CHECK dout0_31 vdout0_31ck23 = 0 time = 240
* CHECK dout0_32 vdout0_32ck23 = 0 time = 240
* CHECK dout0_0 vdout0_0ck24 = 3.3 time = 250
* CHECK dout0_1 vdout0_1ck24 = 3.3 time = 250
* CHECK dout0_2 vdout0_2ck24 = 0 time = 250
* CHECK dout0_3 vdout0_3ck24 = 0 time = 250
* CHECK dout0_4 vdout0_4ck24 = 0 time = 250
* CHECK dout0_5 vdout0_5ck24 = 3.3 time = 250
* CHECK dout0_6 vdout0_6ck24 = 3.3 time = 250
* CHECK dout0_7 vdout0_7ck24 = 0 time = 250
* CHECK dout0_8 vdout0_8ck24 = 3.3 time = 250
* CHECK dout0_9 vdout0_9ck24 = 0 time = 250
* CHECK dout0_10 vdout0_10ck24 = 3.3 time = 250
* CHECK dout0_11 vdout0_11ck24 = 3.3 time = 250
* CHECK dout0_12 vdout0_12ck24 = 3.3 time = 250
* CHECK dout0_13 vdout0_13ck24 = 0 time = 250
* CHECK dout0_14 vdout0_14ck24 = 0 time = 250
* CHECK dout0_15 vdout0_15ck24 = 3.3 time = 250
* CHECK dout0_16 vdout0_16ck24 = 3.3 time = 250
* CHECK dout0_17 vdout0_17ck24 = 0 time = 250
* CHECK dout0_18 vdout0_18ck24 = 3.3 time = 250
* CHECK dout0_19 vdout0_19ck24 = 3.3 time = 250
* CHECK dout0_20 vdout0_20ck24 = 0 time = 250
* CHECK dout0_21 vdout0_21ck24 = 0 time = 250
* CHECK dout0_22 vdout0_22ck24 = 3.3 time = 250
* CHECK dout0_23 vdout0_23ck24 = 3.3 time = 250
* CHECK dout0_24 vdout0_24ck24 = 0 time = 250
* CHECK dout0_25 vdout0_25ck24 = 0 time = 250
* CHECK dout0_26 vdout0_26ck24 = 3.3 time = 250
* CHECK dout0_27 vdout0_27ck24 = 0 time = 250
* CHECK dout0_28 vdout0_28ck24 = 0 time = 250
* CHECK dout0_29 vdout0_29ck24 = 0 time = 250
* CHECK dout0_30 vdout0_30ck24 = 3.3 time = 250
* CHECK dout0_31 vdout0_31ck24 = 0 time = 250
* CHECK dout0_32 vdout0_32ck24 = 0 time = 250
* CHECK dout0_0 vdout0_0ck25 = 3.3 time = 260
* CHECK dout0_1 vdout0_1ck25 = 0 time = 260
* CHECK dout0_2 vdout0_2ck25 = 0 time = 260
* CHECK dout0_3 vdout0_3ck25 = 3.3 time = 260
* CHECK dout0_4 vdout0_4ck25 = 3.3 time = 260
* CHECK dout0_5 vdout0_5ck25 = 0 time = 260
* CHECK dout0_6 vdout0_6ck25 = 3.3 time = 260
* CHECK dout0_7 vdout0_7ck25 = 0 time = 260
* CHECK dout0_8 vdout0_8ck25 = 3.3 time = 260
* CHECK dout0_9 vdout0_9ck25 = 0 time = 260
* CHECK dout0_10 vdout0_10ck25 = 3.3 time = 260
* CHECK dout0_11 vdout0_11ck25 = 0 time = 260
* CHECK dout0_12 vdout0_12ck25 = 3.3 time = 260
* CHECK dout0_13 vdout0_13ck25 = 3.3 time = 260
* CHECK dout0_14 vdout0_14ck25 = 3.3 time = 260
* CHECK dout0_15 vdout0_15ck25 = 0 time = 260
* CHECK dout0_16 vdout0_16ck25 = 0 time = 260
* CHECK dout0_17 vdout0_17ck25 = 3.3 time = 260
* CHECK dout0_18 vdout0_18ck25 = 0 time = 260
* CHECK dout0_19 vdout0_19ck25 = 0 time = 260
* CHECK dout0_20 vdout0_20ck25 = 3.3 time = 260
* CHECK dout0_21 vdout0_21ck25 = 0 time = 260
* CHECK dout0_22 vdout0_22ck25 = 0 time = 260
* CHECK dout0_23 vdout0_23ck25 = 3.3 time = 260
* CHECK dout0_24 vdout0_24ck25 = 3.3 time = 260
* CHECK dout0_25 vdout0_25ck25 = 0 time = 260
* CHECK dout0_26 vdout0_26ck25 = 0 time = 260
* CHECK dout0_27 vdout0_27ck25 = 0 time = 260
* CHECK dout0_28 vdout0_28ck25 = 0 time = 260
* CHECK dout0_29 vdout0_29ck25 = 3.3 time = 260
* CHECK dout0_30 vdout0_30ck25 = 3.3 time = 260
* CHECK dout0_31 vdout0_31ck25 = 0 time = 260
* CHECK dout0_32 vdout0_32ck25 = 0 time = 260
* CHECK dout0_0 vdout0_0ck26 = 3.3 time = 270
* CHECK dout0_1 vdout0_1ck26 = 3.3 time = 270
* CHECK dout0_2 vdout0_2ck26 = 0 time = 270
* CHECK dout0_3 vdout0_3ck26 = 0 time = 270
* CHECK dout0_4 vdout0_4ck26 = 0 time = 270
* CHECK dout0_5 vdout0_5ck26 = 3.3 time = 270
* CHECK dout0_6 vdout0_6ck26 = 3.3 time = 270
* CHECK dout0_7 vdout0_7ck26 = 0 time = 270
* CHECK dout0_8 vdout0_8ck26 = 3.3 time = 270
* CHECK dout0_9 vdout0_9ck26 = 0 time = 270
* CHECK dout0_10 vdout0_10ck26 = 3.3 time = 270
* CHECK dout0_11 vdout0_11ck26 = 3.3 time = 270
* CHECK dout0_12 vdout0_12ck26 = 3.3 time = 270
* CHECK dout0_13 vdout0_13ck26 = 0 time = 270
* CHECK dout0_14 vdout0_14ck26 = 0 time = 270
* CHECK dout0_15 vdout0_15ck26 = 3.3 time = 270
* CHECK dout0_16 vdout0_16ck26 = 3.3 time = 270
* CHECK dout0_17 vdout0_17ck26 = 0 time = 270
* CHECK dout0_18 vdout0_18ck26 = 3.3 time = 270
* CHECK dout0_19 vdout0_19ck26 = 3.3 time = 270
* CHECK dout0_20 vdout0_20ck26 = 0 time = 270
* CHECK dout0_21 vdout0_21ck26 = 0 time = 270
* CHECK dout0_22 vdout0_22ck26 = 3.3 time = 270
* CHECK dout0_23 vdout0_23ck26 = 3.3 time = 270
* CHECK dout0_24 vdout0_24ck26 = 0 time = 270
* CHECK dout0_25 vdout0_25ck26 = 0 time = 270
* CHECK dout0_26 vdout0_26ck26 = 3.3 time = 270
* CHECK dout0_27 vdout0_27ck26 = 0 time = 270
* CHECK dout0_28 vdout0_28ck26 = 0 time = 270
* CHECK dout0_29 vdout0_29ck26 = 0 time = 270
* CHECK dout0_30 vdout0_30ck26 = 3.3 time = 270
* CHECK dout0_31 vdout0_31ck26 = 0 time = 270
* CHECK dout0_32 vdout0_32ck26 = 0 time = 270
* CHECK dout0_0 vdout0_0ck27 = 3.3 time = 280
* CHECK dout0_1 vdout0_1ck27 = 0 time = 280
* CHECK dout0_2 vdout0_2ck27 = 0 time = 280
* CHECK dout0_3 vdout0_3ck27 = 3.3 time = 280
* CHECK dout0_4 vdout0_4ck27 = 3.3 time = 280
* CHECK dout0_5 vdout0_5ck27 = 0 time = 280
* CHECK dout0_6 vdout0_6ck27 = 3.3 time = 280
* CHECK dout0_7 vdout0_7ck27 = 0 time = 280
* CHECK dout0_8 vdout0_8ck27 = 3.3 time = 280
* CHECK dout0_9 vdout0_9ck27 = 0 time = 280
* CHECK dout0_10 vdout0_10ck27 = 3.3 time = 280
* CHECK dout0_11 vdout0_11ck27 = 0 time = 280
* CHECK dout0_12 vdout0_12ck27 = 3.3 time = 280
* CHECK dout0_13 vdout0_13ck27 = 3.3 time = 280
* CHECK dout0_14 vdout0_14ck27 = 3.3 time = 280
* CHECK dout0_15 vdout0_15ck27 = 0 time = 280
* CHECK dout0_16 vdout0_16ck27 = 0 time = 280
* CHECK dout0_17 vdout0_17ck27 = 3.3 time = 280
* CHECK dout0_18 vdout0_18ck27 = 0 time = 280
* CHECK dout0_19 vdout0_19ck27 = 0 time = 280
* CHECK dout0_20 vdout0_20ck27 = 3.3 time = 280
* CHECK dout0_21 vdout0_21ck27 = 0 time = 280
* CHECK dout0_22 vdout0_22ck27 = 0 time = 280
* CHECK dout0_23 vdout0_23ck27 = 3.3 time = 280
* CHECK dout0_24 vdout0_24ck27 = 3.3 time = 280
* CHECK dout0_25 vdout0_25ck27 = 0 time = 280
* CHECK dout0_26 vdout0_26ck27 = 0 time = 280
* CHECK dout0_27 vdout0_27ck27 = 0 time = 280
* CHECK dout0_28 vdout0_28ck27 = 0 time = 280
* CHECK dout0_29 vdout0_29ck27 = 3.3 time = 280
* CHECK dout0_30 vdout0_30ck27 = 3.3 time = 280
* CHECK dout0_31 vdout0_31ck27 = 0 time = 280
* CHECK dout0_32 vdout0_32ck27 = 0 time = 280
* CHECK dout0_0 vdout0_0ck28 = 3.3 time = 290
* CHECK dout0_1 vdout0_1ck28 = 0 time = 290
* CHECK dout0_2 vdout0_2ck28 = 0 time = 290
* CHECK dout0_3 vdout0_3ck28 = 3.3 time = 290
* CHECK dout0_4 vdout0_4ck28 = 3.3 time = 290
* CHECK dout0_5 vdout0_5ck28 = 0 time = 290
* CHECK dout0_6 vdout0_6ck28 = 3.3 time = 290
* CHECK dout0_7 vdout0_7ck28 = 0 time = 290
* CHECK dout0_8 vdout0_8ck28 = 3.3 time = 290
* CHECK dout0_9 vdout0_9ck28 = 0 time = 290
* CHECK dout0_10 vdout0_10ck28 = 3.3 time = 290
* CHECK dout0_11 vdout0_11ck28 = 0 time = 290
* CHECK dout0_12 vdout0_12ck28 = 3.3 time = 290
* CHECK dout0_13 vdout0_13ck28 = 3.3 time = 290
* CHECK dout0_14 vdout0_14ck28 = 3.3 time = 290
* CHECK dout0_15 vdout0_15ck28 = 0 time = 290
* CHECK dout0_16 vdout0_16ck28 = 0 time = 290
* CHECK dout0_17 vdout0_17ck28 = 3.3 time = 290
* CHECK dout0_18 vdout0_18ck28 = 0 time = 290
* CHECK dout0_19 vdout0_19ck28 = 0 time = 290
* CHECK dout0_20 vdout0_20ck28 = 3.3 time = 290
* CHECK dout0_21 vdout0_21ck28 = 0 time = 290
* CHECK dout0_22 vdout0_22ck28 = 0 time = 290
* CHECK dout0_23 vdout0_23ck28 = 3.3 time = 290
* CHECK dout0_24 vdout0_24ck28 = 3.3 time = 290
* CHECK dout0_25 vdout0_25ck28 = 0 time = 290
* CHECK dout0_26 vdout0_26ck28 = 0 time = 290
* CHECK dout0_27 vdout0_27ck28 = 0 time = 290
* CHECK dout0_28 vdout0_28ck28 = 0 time = 290
* CHECK dout0_29 vdout0_29ck28 = 3.3 time = 290
* CHECK dout0_30 vdout0_30ck28 = 3.3 time = 290
* CHECK dout0_31 vdout0_31ck28 = 0 time = 290
* CHECK dout0_32 vdout0_32ck28 = 0 time = 290
* CHECK dout0_0 vdout0_0ck33 = 3.3 time = 340
* CHECK dout0_1 vdout0_1ck33 = 3.3 time = 340
* CHECK dout0_2 vdout0_2ck33 = 0 time = 340
* CHECK dout0_3 vdout0_3ck33 = 0 time = 340
* CHECK dout0_4 vdout0_4ck33 = 0 time = 340
* CHECK dout0_5 vdout0_5ck33 = 3.3 time = 340
* CHECK dout0_6 vdout0_6ck33 = 3.3 time = 340
* CHECK dout0_7 vdout0_7ck33 = 0 time = 340
* CHECK dout0_8 vdout0_8ck33 = 3.3 time = 340
* CHECK dout0_9 vdout0_9ck33 = 0 time = 340
* CHECK dout0_10 vdout0_10ck33 = 3.3 time = 340
* CHECK dout0_11 vdout0_11ck33 = 3.3 time = 340
* CHECK dout0_12 vdout0_12ck33 = 3.3 time = 340
* CHECK dout0_13 vdout0_13ck33 = 0 time = 340
* CHECK dout0_14 vdout0_14ck33 = 0 time = 340
* CHECK dout0_15 vdout0_15ck33 = 3.3 time = 340
* CHECK dout0_16 vdout0_16ck33 = 3.3 time = 340
* CHECK dout0_17 vdout0_17ck33 = 0 time = 340
* CHECK dout0_18 vdout0_18ck33 = 3.3 time = 340
* CHECK dout0_19 vdout0_19ck33 = 3.3 time = 340
* CHECK dout0_20 vdout0_20ck33 = 0 time = 340
* CHECK dout0_21 vdout0_21ck33 = 0 time = 340
* CHECK dout0_22 vdout0_22ck33 = 3.3 time = 340
* CHECK dout0_23 vdout0_23ck33 = 3.3 time = 340
* CHECK dout0_24 vdout0_24ck33 = 0 time = 340
* CHECK dout0_25 vdout0_25ck33 = 0 time = 340
* CHECK dout0_26 vdout0_26ck33 = 3.3 time = 340
* CHECK dout0_27 vdout0_27ck33 = 0 time = 340
* CHECK dout0_28 vdout0_28ck33 = 0 time = 340
* CHECK dout0_29 vdout0_29ck33 = 0 time = 340
* CHECK dout0_30 vdout0_30ck33 = 3.3 time = 340
* CHECK dout0_31 vdout0_31ck33 = 0 time = 340
* CHECK dout0_32 vdout0_32ck33 = 0 time = 340
* CHECK dout0_0 vdout0_0ck34 = 3.3 time = 350
* CHECK dout0_1 vdout0_1ck34 = 3.3 time = 350
* CHECK dout0_2 vdout0_2ck34 = 0 time = 350
* CHECK dout0_3 vdout0_3ck34 = 3.3 time = 350
* CHECK dout0_4 vdout0_4ck34 = 3.3 time = 350
* CHECK dout0_5 vdout0_5ck34 = 3.3 time = 350
* CHECK dout0_6 vdout0_6ck34 = 0 time = 350
* CHECK dout0_7 vdout0_7ck34 = 0 time = 350
* CHECK dout0_8 vdout0_8ck34 = 3.3 time = 350
* CHECK dout0_9 vdout0_9ck34 = 0 time = 350
* CHECK dout0_10 vdout0_10ck34 = 0 time = 350
* CHECK dout0_11 vdout0_11ck34 = 0 time = 350
* CHECK dout0_12 vdout0_12ck34 = 0 time = 350
* CHECK dout0_13 vdout0_13ck34 = 0 time = 350
* CHECK dout0_14 vdout0_14ck34 = 0 time = 350
* CHECK dout0_15 vdout0_15ck34 = 0 time = 350
* CHECK dout0_16 vdout0_16ck34 = 0 time = 350
* CHECK dout0_17 vdout0_17ck34 = 3.3 time = 350
* CHECK dout0_18 vdout0_18ck34 = 3.3 time = 350
* CHECK dout0_19 vdout0_19ck34 = 0 time = 350
* CHECK dout0_20 vdout0_20ck34 = 0 time = 350
* CHECK dout0_21 vdout0_21ck34 = 3.3 time = 350
* CHECK dout0_22 vdout0_22ck34 = 0 time = 350
* CHECK dout0_23 vdout0_23ck34 = 3.3 time = 350
* CHECK dout0_24 vdout0_24ck34 = 0 time = 350
* CHECK dout0_25 vdout0_25ck34 = 3.3 time = 350
* CHECK dout0_26 vdout0_26ck34 = 0 time = 350
* CHECK dout0_27 vdout0_27ck34 = 3.3 time = 350
* CHECK dout0_28 vdout0_28ck34 = 3.3 time = 350
* CHECK dout0_29 vdout0_29ck34 = 3.3 time = 350
* CHECK dout0_30 vdout0_30ck34 = 3.3 time = 350
* CHECK dout0_31 vdout0_31ck34 = 3.3 time = 350
* CHECK dout0_32 vdout0_32ck34 = 0 time = 350
* CHECK dout0_0 vdout0_0ck36 = 3.3 time = 370
* CHECK dout0_1 vdout0_1ck36 = 3.3 time = 370
* CHECK dout0_2 vdout0_2ck36 = 0 time = 370
* CHECK dout0_3 vdout0_3ck36 = 0 time = 370
* CHECK dout0_4 vdout0_4ck36 = 0 time = 370
* CHECK dout0_5 vdout0_5ck36 = 3.3 time = 370
* CHECK dout0_6 vdout0_6ck36 = 3.3 time = 370
* CHECK dout0_7 vdout0_7ck36 = 0 time = 370
* CHECK dout0_8 vdout0_8ck36 = 3.3 time = 370
* CHECK dout0_9 vdout0_9ck36 = 0 time = 370
* CHECK dout0_10 vdout0_10ck36 = 3.3 time = 370
* CHECK dout0_11 vdout0_11ck36 = 3.3 time = 370
* CHECK dout0_12 vdout0_12ck36 = 3.3 time = 370
* CHECK dout0_13 vdout0_13ck36 = 0 time = 370
* CHECK dout0_14 vdout0_14ck36 = 0 time = 370
* CHECK dout0_15 vdout0_15ck36 = 3.3 time = 370
* CHECK dout0_16 vdout0_16ck36 = 3.3 time = 370
* CHECK dout0_17 vdout0_17ck36 = 0 time = 370
* CHECK dout0_18 vdout0_18ck36 = 3.3 time = 370
* CHECK dout0_19 vdout0_19ck36 = 3.3 time = 370
* CHECK dout0_20 vdout0_20ck36 = 0 time = 370
* CHECK dout0_21 vdout0_21ck36 = 0 time = 370
* CHECK dout0_22 vdout0_22ck36 = 3.3 time = 370
* CHECK dout0_23 vdout0_23ck36 = 3.3 time = 370
* CHECK dout0_24 vdout0_24ck36 = 0 time = 370
* CHECK dout0_25 vdout0_25ck36 = 0 time = 370
* CHECK dout0_26 vdout0_26ck36 = 3.3 time = 370
* CHECK dout0_27 vdout0_27ck36 = 0 time = 370
* CHECK dout0_28 vdout0_28ck36 = 0 time = 370
* CHECK dout0_29 vdout0_29ck36 = 0 time = 370
* CHECK dout0_30 vdout0_30ck36 = 3.3 time = 370
* CHECK dout0_31 vdout0_31ck36 = 0 time = 370
* CHECK dout0_32 vdout0_32ck36 = 0 time = 370
* CHECK dout0_0 vdout0_0ck37 = 3.3 time = 380
* CHECK dout0_1 vdout0_1ck37 = 3.3 time = 380
* CHECK dout0_2 vdout0_2ck37 = 0 time = 380
* CHECK dout0_3 vdout0_3ck37 = 0 time = 380
* CHECK dout0_4 vdout0_4ck37 = 0 time = 380
* CHECK dout0_5 vdout0_5ck37 = 3.3 time = 380
* CHECK dout0_6 vdout0_6ck37 = 3.3 time = 380
* CHECK dout0_7 vdout0_7ck37 = 0 time = 380
* CHECK dout0_8 vdout0_8ck37 = 3.3 time = 380
* CHECK dout0_9 vdout0_9ck37 = 0 time = 380
* CHECK dout0_10 vdout0_10ck37 = 3.3 time = 380
* CHECK dout0_11 vdout0_11ck37 = 3.3 time = 380
* CHECK dout0_12 vdout0_12ck37 = 3.3 time = 380
* CHECK dout0_13 vdout0_13ck37 = 0 time = 380
* CHECK dout0_14 vdout0_14ck37 = 0 time = 380
* CHECK dout0_15 vdout0_15ck37 = 3.3 time = 380
* CHECK dout0_16 vdout0_16ck37 = 3.3 time = 380
* CHECK dout0_17 vdout0_17ck37 = 0 time = 380
* CHECK dout0_18 vdout0_18ck37 = 3.3 time = 380
* CHECK dout0_19 vdout0_19ck37 = 3.3 time = 380
* CHECK dout0_20 vdout0_20ck37 = 0 time = 380
* CHECK dout0_21 vdout0_21ck37 = 0 time = 380
* CHECK dout0_22 vdout0_22ck37 = 3.3 time = 380
* CHECK dout0_23 vdout0_23ck37 = 3.3 time = 380
* CHECK dout0_24 vdout0_24ck37 = 0 time = 380
* CHECK dout0_25 vdout0_25ck37 = 0 time = 380
* CHECK dout0_26 vdout0_26ck37 = 3.3 time = 380
* CHECK dout0_27 vdout0_27ck37 = 0 time = 380
* CHECK dout0_28 vdout0_28ck37 = 0 time = 380
* CHECK dout0_29 vdout0_29ck37 = 0 time = 380
* CHECK dout0_30 vdout0_30ck37 = 3.3 time = 380
* CHECK dout0_31 vdout0_31ck37 = 0 time = 380
* CHECK dout0_32 vdout0_32ck37 = 0 time = 380
* CHECK dout0_0 vdout0_0ck42 = 3.3 time = 430
* CHECK dout0_1 vdout0_1ck42 = 3.3 time = 430
* CHECK dout0_2 vdout0_2ck42 = 3.3 time = 430
* CHECK dout0_3 vdout0_3ck42 = 0 time = 430
* CHECK dout0_4 vdout0_4ck42 = 0 time = 430
* CHECK dout0_5 vdout0_5ck42 = 0 time = 430
* CHECK dout0_6 vdout0_6ck42 = 3.3 time = 430
* CHECK dout0_7 vdout0_7ck42 = 0 time = 430
* CHECK dout0_8 vdout0_8ck42 = 0 time = 430
* CHECK dout0_9 vdout0_9ck42 = 0 time = 430
* CHECK dout0_10 vdout0_10ck42 = 3.3 time = 430
* CHECK dout0_11 vdout0_11ck42 = 0 time = 430
* CHECK dout0_12 vdout0_12ck42 = 3.3 time = 430
* CHECK dout0_13 vdout0_13ck42 = 0 time = 430
* CHECK dout0_14 vdout0_14ck42 = 3.3 time = 430
* CHECK dout0_15 vdout0_15ck42 = 0 time = 430
* CHECK dout0_16 vdout0_16ck42 = 3.3 time = 430
* CHECK dout0_17 vdout0_17ck42 = 3.3 time = 430
* CHECK dout0_18 vdout0_18ck42 = 0 time = 430
* CHECK dout0_19 vdout0_19ck42 = 3.3 time = 430
* CHECK dout0_20 vdout0_20ck42 = 0 time = 430
* CHECK dout0_21 vdout0_21ck42 = 3.3 time = 430
* CHECK dout0_22 vdout0_22ck42 = 0 time = 430
* CHECK dout0_23 vdout0_23ck42 = 3.3 time = 430
* CHECK dout0_24 vdout0_24ck42 = 3.3 time = 430
* CHECK dout0_25 vdout0_25ck42 = 0 time = 430
* CHECK dout0_26 vdout0_26ck42 = 3.3 time = 430
* CHECK dout0_27 vdout0_27ck42 = 0 time = 430
* CHECK dout0_28 vdout0_28ck42 = 0 time = 430
* CHECK dout0_29 vdout0_29ck42 = 3.3 time = 430
* CHECK dout0_30 vdout0_30ck42 = 3.3 time = 430
* CHECK dout0_31 vdout0_31ck42 = 0 time = 430
* CHECK dout0_32 vdout0_32ck42 = 0 time = 430
* CHECK dout0_0 vdout0_0ck43 = 3.3 time = 440
* CHECK dout0_1 vdout0_1ck43 = 3.3 time = 440
* CHECK dout0_2 vdout0_2ck43 = 3.3 time = 440
* CHECK dout0_3 vdout0_3ck43 = 0 time = 440
* CHECK dout0_4 vdout0_4ck43 = 0 time = 440
* CHECK dout0_5 vdout0_5ck43 = 0 time = 440
* CHECK dout0_6 vdout0_6ck43 = 3.3 time = 440
* CHECK dout0_7 vdout0_7ck43 = 0 time = 440
* CHECK dout0_8 vdout0_8ck43 = 0 time = 440
* CHECK dout0_9 vdout0_9ck43 = 0 time = 440
* CHECK dout0_10 vdout0_10ck43 = 3.3 time = 440
* CHECK dout0_11 vdout0_11ck43 = 0 time = 440
* CHECK dout0_12 vdout0_12ck43 = 3.3 time = 440
* CHECK dout0_13 vdout0_13ck43 = 0 time = 440
* CHECK dout0_14 vdout0_14ck43 = 3.3 time = 440
* CHECK dout0_15 vdout0_15ck43 = 0 time = 440
* CHECK dout0_16 vdout0_16ck43 = 3.3 time = 440
* CHECK dout0_17 vdout0_17ck43 = 3.3 time = 440
* CHECK dout0_18 vdout0_18ck43 = 0 time = 440
* CHECK dout0_19 vdout0_19ck43 = 3.3 time = 440
* CHECK dout0_20 vdout0_20ck43 = 0 time = 440
* CHECK dout0_21 vdout0_21ck43 = 3.3 time = 440
* CHECK dout0_22 vdout0_22ck43 = 0 time = 440
* CHECK dout0_23 vdout0_23ck43 = 3.3 time = 440
* CHECK dout0_24 vdout0_24ck43 = 3.3 time = 440
* CHECK dout0_25 vdout0_25ck43 = 0 time = 440
* CHECK dout0_26 vdout0_26ck43 = 3.3 time = 440
* CHECK dout0_27 vdout0_27ck43 = 0 time = 440
* CHECK dout0_28 vdout0_28ck43 = 0 time = 440
* CHECK dout0_29 vdout0_29ck43 = 3.3 time = 440
* CHECK dout0_30 vdout0_30ck43 = 3.3 time = 440
* CHECK dout0_31 vdout0_31ck43 = 0 time = 440
* CHECK dout0_32 vdout0_32ck43 = 0 time = 440
* CHECK dout0_0 vdout0_0ck44 = 3.3 time = 450
* CHECK dout0_1 vdout0_1ck44 = 0 time = 450
* CHECK dout0_2 vdout0_2ck44 = 3.3 time = 450
* CHECK dout0_3 vdout0_3ck44 = 0 time = 450
* CHECK dout0_4 vdout0_4ck44 = 3.3 time = 450
* CHECK dout0_5 vdout0_5ck44 = 0 time = 450
* CHECK dout0_6 vdout0_6ck44 = 3.3 time = 450
* CHECK dout0_7 vdout0_7ck44 = 3.3 time = 450
* CHECK dout0_8 vdout0_8ck44 = 0 time = 450
* CHECK dout0_9 vdout0_9ck44 = 3.3 time = 450
* CHECK dout0_10 vdout0_10ck44 = 3.3 time = 450
* CHECK dout0_11 vdout0_11ck44 = 0 time = 450
* CHECK dout0_12 vdout0_12ck44 = 3.3 time = 450
* CHECK dout0_13 vdout0_13ck44 = 3.3 time = 450
* CHECK dout0_14 vdout0_14ck44 = 0 time = 450
* CHECK dout0_15 vdout0_15ck44 = 3.3 time = 450
* CHECK dout0_16 vdout0_16ck44 = 0 time = 450
* CHECK dout0_17 vdout0_17ck44 = 3.3 time = 450
* CHECK dout0_18 vdout0_18ck44 = 0 time = 450
* CHECK dout0_19 vdout0_19ck44 = 3.3 time = 450
* CHECK dout0_20 vdout0_20ck44 = 3.3 time = 450
* CHECK dout0_21 vdout0_21ck44 = 3.3 time = 450
* CHECK dout0_22 vdout0_22ck44 = 0 time = 450
* CHECK dout0_23 vdout0_23ck44 = 3.3 time = 450
* CHECK dout0_24 vdout0_24ck44 = 3.3 time = 450
* CHECK dout0_25 vdout0_25ck44 = 0 time = 450
* CHECK dout0_26 vdout0_26ck44 = 3.3 time = 450
* CHECK dout0_27 vdout0_27ck44 = 0 time = 450
* CHECK dout0_28 vdout0_28ck44 = 0 time = 450
* CHECK dout0_29 vdout0_29ck44 = 0 time = 450
* CHECK dout0_30 vdout0_30ck44 = 0 time = 450
* CHECK dout0_31 vdout0_31ck44 = 3.3 time = 450
* CHECK dout0_32 vdout0_32ck44 = 0 time = 450
* CHECK dout0_0 vdout0_0ck45 = 3.3 time = 460
* CHECK dout0_1 vdout0_1ck45 = 3.3 time = 460
* CHECK dout0_2 vdout0_2ck45 = 3.3 time = 460
* CHECK dout0_3 vdout0_3ck45 = 0 time = 460
* CHECK dout0_4 vdout0_4ck45 = 0 time = 460
* CHECK dout0_5 vdout0_5ck45 = 0 time = 460
* CHECK dout0_6 vdout0_6ck45 = 3.3 time = 460
* CHECK dout0_7 vdout0_7ck45 = 0 time = 460
* CHECK dout0_8 vdout0_8ck45 = 0 time = 460
* CHECK dout0_9 vdout0_9ck45 = 0 time = 460
* CHECK dout0_10 vdout0_10ck45 = 3.3 time = 460
* CHECK dout0_11 vdout0_11ck45 = 0 time = 460
* CHECK dout0_12 vdout0_12ck45 = 3.3 time = 460
* CHECK dout0_13 vdout0_13ck45 = 0 time = 460
* CHECK dout0_14 vdout0_14ck45 = 3.3 time = 460
* CHECK dout0_15 vdout0_15ck45 = 0 time = 460
* CHECK dout0_16 vdout0_16ck45 = 3.3 time = 460
* CHECK dout0_17 vdout0_17ck45 = 3.3 time = 460
* CHECK dout0_18 vdout0_18ck45 = 0 time = 460
* CHECK dout0_19 vdout0_19ck45 = 3.3 time = 460
* CHECK dout0_20 vdout0_20ck45 = 0 time = 460
* CHECK dout0_21 vdout0_21ck45 = 3.3 time = 460
* CHECK dout0_22 vdout0_22ck45 = 0 time = 460
* CHECK dout0_23 vdout0_23ck45 = 3.3 time = 460
* CHECK dout0_24 vdout0_24ck45 = 3.3 time = 460
* CHECK dout0_25 vdout0_25ck45 = 0 time = 460
* CHECK dout0_26 vdout0_26ck45 = 3.3 time = 460
* CHECK dout0_27 vdout0_27ck45 = 0 time = 460
* CHECK dout0_28 vdout0_28ck45 = 0 time = 460
* CHECK dout0_29 vdout0_29ck45 = 3.3 time = 460
* CHECK dout0_30 vdout0_30ck45 = 3.3 time = 460
* CHECK dout0_31 vdout0_31ck45 = 0 time = 460
* CHECK dout0_32 vdout0_32ck45 = 0 time = 460
* CHECK dout0_0 vdout0_0ck46 = 3.3 time = 470
* CHECK dout0_1 vdout0_1ck46 = 3.3 time = 470
* CHECK dout0_2 vdout0_2ck46 = 3.3 time = 470
* CHECK dout0_3 vdout0_3ck46 = 0 time = 470
* CHECK dout0_4 vdout0_4ck46 = 0 time = 470
* CHECK dout0_5 vdout0_5ck46 = 0 time = 470
* CHECK dout0_6 vdout0_6ck46 = 3.3 time = 470
* CHECK dout0_7 vdout0_7ck46 = 0 time = 470
* CHECK dout0_8 vdout0_8ck46 = 0 time = 470
* CHECK dout0_9 vdout0_9ck46 = 0 time = 470
* CHECK dout0_10 vdout0_10ck46 = 3.3 time = 470
* CHECK dout0_11 vdout0_11ck46 = 0 time = 470
* CHECK dout0_12 vdout0_12ck46 = 3.3 time = 470
* CHECK dout0_13 vdout0_13ck46 = 0 time = 470
* CHECK dout0_14 vdout0_14ck46 = 3.3 time = 470
* CHECK dout0_15 vdout0_15ck46 = 0 time = 470
* CHECK dout0_16 vdout0_16ck46 = 3.3 time = 470
* CHECK dout0_17 vdout0_17ck46 = 3.3 time = 470
* CHECK dout0_18 vdout0_18ck46 = 0 time = 470
* CHECK dout0_19 vdout0_19ck46 = 3.3 time = 470
* CHECK dout0_20 vdout0_20ck46 = 0 time = 470
* CHECK dout0_21 vdout0_21ck46 = 3.3 time = 470
* CHECK dout0_22 vdout0_22ck46 = 0 time = 470
* CHECK dout0_23 vdout0_23ck46 = 3.3 time = 470
* CHECK dout0_24 vdout0_24ck46 = 3.3 time = 470
* CHECK dout0_25 vdout0_25ck46 = 0 time = 470
* CHECK dout0_26 vdout0_26ck46 = 3.3 time = 470
* CHECK dout0_27 vdout0_27ck46 = 0 time = 470
* CHECK dout0_28 vdout0_28ck46 = 0 time = 470
* CHECK dout0_29 vdout0_29ck46 = 3.3 time = 470
* CHECK dout0_30 vdout0_30ck46 = 3.3 time = 470
* CHECK dout0_31 vdout0_31ck46 = 0 time = 470
* CHECK dout0_32 vdout0_32ck46 = 0 time = 470
* CHECK dout0_0 vdout0_0ck47 = 3.3 time = 480
* CHECK dout0_1 vdout0_1ck47 = 3.3 time = 480
* CHECK dout0_2 vdout0_2ck47 = 3.3 time = 480
* CHECK dout0_3 vdout0_3ck47 = 0 time = 480
* CHECK dout0_4 vdout0_4ck47 = 0 time = 480
* CHECK dout0_5 vdout0_5ck47 = 0 time = 480
* CHECK dout0_6 vdout0_6ck47 = 3.3 time = 480
* CHECK dout0_7 vdout0_7ck47 = 0 time = 480
* CHECK dout0_8 vdout0_8ck47 = 0 time = 480
* CHECK dout0_9 vdout0_9ck47 = 0 time = 480
* CHECK dout0_10 vdout0_10ck47 = 3.3 time = 480
* CHECK dout0_11 vdout0_11ck47 = 0 time = 480
* CHECK dout0_12 vdout0_12ck47 = 3.3 time = 480
* CHECK dout0_13 vdout0_13ck47 = 0 time = 480
* CHECK dout0_14 vdout0_14ck47 = 3.3 time = 480
* CHECK dout0_15 vdout0_15ck47 = 0 time = 480
* CHECK dout0_16 vdout0_16ck47 = 3.3 time = 480
* CHECK dout0_17 vdout0_17ck47 = 3.3 time = 480
* CHECK dout0_18 vdout0_18ck47 = 0 time = 480
* CHECK dout0_19 vdout0_19ck47 = 3.3 time = 480
* CHECK dout0_20 vdout0_20ck47 = 0 time = 480
* CHECK dout0_21 vdout0_21ck47 = 3.3 time = 480
* CHECK dout0_22 vdout0_22ck47 = 0 time = 480
* CHECK dout0_23 vdout0_23ck47 = 3.3 time = 480
* CHECK dout0_24 vdout0_24ck47 = 3.3 time = 480
* CHECK dout0_25 vdout0_25ck47 = 0 time = 480
* CHECK dout0_26 vdout0_26ck47 = 3.3 time = 480
* CHECK dout0_27 vdout0_27ck47 = 0 time = 480
* CHECK dout0_28 vdout0_28ck47 = 0 time = 480
* CHECK dout0_29 vdout0_29ck47 = 3.3 time = 480
* CHECK dout0_30 vdout0_30ck47 = 3.3 time = 480
* CHECK dout0_31 vdout0_31ck47 = 0 time = 480
* CHECK dout0_32 vdout0_32ck47 = 0 time = 480
* CHECK dout0_0 vdout0_0ck48 = 3.3 time = 490
* CHECK dout0_1 vdout0_1ck48 = 0 time = 490
* CHECK dout0_2 vdout0_2ck48 = 3.3 time = 490
* CHECK dout0_3 vdout0_3ck48 = 0 time = 490
* CHECK dout0_4 vdout0_4ck48 = 3.3 time = 490
* CHECK dout0_5 vdout0_5ck48 = 0 time = 490
* CHECK dout0_6 vdout0_6ck48 = 3.3 time = 490
* CHECK dout0_7 vdout0_7ck48 = 3.3 time = 490
* CHECK dout0_8 vdout0_8ck48 = 0 time = 490
* CHECK dout0_9 vdout0_9ck48 = 3.3 time = 490
* CHECK dout0_10 vdout0_10ck48 = 3.3 time = 490
* CHECK dout0_11 vdout0_11ck48 = 0 time = 490
* CHECK dout0_12 vdout0_12ck48 = 3.3 time = 490
* CHECK dout0_13 vdout0_13ck48 = 3.3 time = 490
* CHECK dout0_14 vdout0_14ck48 = 0 time = 490
* CHECK dout0_15 vdout0_15ck48 = 3.3 time = 490
* CHECK dout0_16 vdout0_16ck48 = 0 time = 490
* CHECK dout0_17 vdout0_17ck48 = 3.3 time = 490
* CHECK dout0_18 vdout0_18ck48 = 0 time = 490
* CHECK dout0_19 vdout0_19ck48 = 3.3 time = 490
* CHECK dout0_20 vdout0_20ck48 = 3.3 time = 490
* CHECK dout0_21 vdout0_21ck48 = 3.3 time = 490
* CHECK dout0_22 vdout0_22ck48 = 0 time = 490
* CHECK dout0_23 vdout0_23ck48 = 3.3 time = 490
* CHECK dout0_24 vdout0_24ck48 = 3.3 time = 490
* CHECK dout0_25 vdout0_25ck48 = 0 time = 490
* CHECK dout0_26 vdout0_26ck48 = 3.3 time = 490
* CHECK dout0_27 vdout0_27ck48 = 0 time = 490
* CHECK dout0_28 vdout0_28ck48 = 0 time = 490
* CHECK dout0_29 vdout0_29ck48 = 0 time = 490
* CHECK dout0_30 vdout0_30ck48 = 0 time = 490
* CHECK dout0_31 vdout0_31ck48 = 3.3 time = 490
* CHECK dout0_32 vdout0_32ck48 = 0 time = 490
* CHECK dout0_0 vdout0_0ck49 = 3.3 time = 500
* CHECK dout0_1 vdout0_1ck49 = 3.3 time = 500
* CHECK dout0_2 vdout0_2ck49 = 3.3 time = 500
* CHECK dout0_3 vdout0_3ck49 = 0 time = 500
* CHECK dout0_4 vdout0_4ck49 = 0 time = 500
* CHECK dout0_5 vdout0_5ck49 = 0 time = 500
* CHECK dout0_6 vdout0_6ck49 = 3.3 time = 500
* CHECK dout0_7 vdout0_7ck49 = 0 time = 500
* CHECK dout0_8 vdout0_8ck49 = 0 time = 500
* CHECK dout0_9 vdout0_9ck49 = 0 time = 500
* CHECK dout0_10 vdout0_10ck49 = 3.3 time = 500
* CHECK dout0_11 vdout0_11ck49 = 0 time = 500
* CHECK dout0_12 vdout0_12ck49 = 3.3 time = 500
* CHECK dout0_13 vdout0_13ck49 = 0 time = 500
* CHECK dout0_14 vdout0_14ck49 = 3.3 time = 500
* CHECK dout0_15 vdout0_15ck49 = 0 time = 500
* CHECK dout0_16 vdout0_16ck49 = 3.3 time = 500
* CHECK dout0_17 vdout0_17ck49 = 3.3 time = 500
* CHECK dout0_18 vdout0_18ck49 = 0 time = 500
* CHECK dout0_19 vdout0_19ck49 = 3.3 time = 500
* CHECK dout0_20 vdout0_20ck49 = 0 time = 500
* CHECK dout0_21 vdout0_21ck49 = 3.3 time = 500
* CHECK dout0_22 vdout0_22ck49 = 0 time = 500
* CHECK dout0_23 vdout0_23ck49 = 3.3 time = 500
* CHECK dout0_24 vdout0_24ck49 = 3.3 time = 500
* CHECK dout0_25 vdout0_25ck49 = 0 time = 500
* CHECK dout0_26 vdout0_26ck49 = 3.3 time = 500
* CHECK dout0_27 vdout0_27ck49 = 0 time = 500
* CHECK dout0_28 vdout0_28ck49 = 0 time = 500
* CHECK dout0_29 vdout0_29ck49 = 3.3 time = 500
* CHECK dout0_30 vdout0_30ck49 = 3.3 time = 500
* CHECK dout0_31 vdout0_31ck49 = 0 time = 500
* CHECK dout0_32 vdout0_32ck49 = 0 time = 500
* CHECK dout0_0 vdout0_0ck53 = 3.3 time = 540
* CHECK dout0_1 vdout0_1ck53 = 3.3 time = 540
* CHECK dout0_2 vdout0_2ck53 = 3.3 time = 540
* CHECK dout0_3 vdout0_3ck53 = 0 time = 540
* CHECK dout0_4 vdout0_4ck53 = 0 time = 540
* CHECK dout0_5 vdout0_5ck53 = 0 time = 540
* CHECK dout0_6 vdout0_6ck53 = 3.3 time = 540
* CHECK dout0_7 vdout0_7ck53 = 0 time = 540
* CHECK dout0_8 vdout0_8ck53 = 0 time = 540
* CHECK dout0_9 vdout0_9ck53 = 0 time = 540
* CHECK dout0_10 vdout0_10ck53 = 3.3 time = 540
* CHECK dout0_11 vdout0_11ck53 = 0 time = 540
* CHECK dout0_12 vdout0_12ck53 = 3.3 time = 540
* CHECK dout0_13 vdout0_13ck53 = 0 time = 540
* CHECK dout0_14 vdout0_14ck53 = 3.3 time = 540
* CHECK dout0_15 vdout0_15ck53 = 0 time = 540
* CHECK dout0_16 vdout0_16ck53 = 3.3 time = 540
* CHECK dout0_17 vdout0_17ck53 = 3.3 time = 540
* CHECK dout0_18 vdout0_18ck53 = 0 time = 540
* CHECK dout0_19 vdout0_19ck53 = 3.3 time = 540
* CHECK dout0_20 vdout0_20ck53 = 0 time = 540
* CHECK dout0_21 vdout0_21ck53 = 3.3 time = 540
* CHECK dout0_22 vdout0_22ck53 = 0 time = 540
* CHECK dout0_23 vdout0_23ck53 = 3.3 time = 540
* CHECK dout0_24 vdout0_24ck53 = 3.3 time = 540
* CHECK dout0_25 vdout0_25ck53 = 0 time = 540
* CHECK dout0_26 vdout0_26ck53 = 3.3 time = 540
* CHECK dout0_27 vdout0_27ck53 = 0 time = 540
* CHECK dout0_28 vdout0_28ck53 = 0 time = 540
* CHECK dout0_29 vdout0_29ck53 = 3.3 time = 540
* CHECK dout0_30 vdout0_30ck53 = 3.3 time = 540
* CHECK dout0_31 vdout0_31ck53 = 0 time = 540
* CHECK dout0_32 vdout0_32ck53 = 0 time = 540
* CHECK dout0_0 vdout0_0ck54 = 3.3 time = 550
* CHECK dout0_1 vdout0_1ck54 = 3.3 time = 550
* CHECK dout0_2 vdout0_2ck54 = 3.3 time = 550
* CHECK dout0_3 vdout0_3ck54 = 0 time = 550
* CHECK dout0_4 vdout0_4ck54 = 0 time = 550
* CHECK dout0_5 vdout0_5ck54 = 0 time = 550
* CHECK dout0_6 vdout0_6ck54 = 3.3 time = 550
* CHECK dout0_7 vdout0_7ck54 = 0 time = 550
* CHECK dout0_8 vdout0_8ck54 = 0 time = 550
* CHECK dout0_9 vdout0_9ck54 = 0 time = 550
* CHECK dout0_10 vdout0_10ck54 = 3.3 time = 550
* CHECK dout0_11 vdout0_11ck54 = 0 time = 550
* CHECK dout0_12 vdout0_12ck54 = 3.3 time = 550
* CHECK dout0_13 vdout0_13ck54 = 0 time = 550
* CHECK dout0_14 vdout0_14ck54 = 3.3 time = 550
* CHECK dout0_15 vdout0_15ck54 = 0 time = 550
* CHECK dout0_16 vdout0_16ck54 = 3.3 time = 550
* CHECK dout0_17 vdout0_17ck54 = 3.3 time = 550
* CHECK dout0_18 vdout0_18ck54 = 0 time = 550
* CHECK dout0_19 vdout0_19ck54 = 3.3 time = 550
* CHECK dout0_20 vdout0_20ck54 = 0 time = 550
* CHECK dout0_21 vdout0_21ck54 = 3.3 time = 550
* CHECK dout0_22 vdout0_22ck54 = 0 time = 550
* CHECK dout0_23 vdout0_23ck54 = 3.3 time = 550
* CHECK dout0_24 vdout0_24ck54 = 3.3 time = 550
* CHECK dout0_25 vdout0_25ck54 = 0 time = 550
* CHECK dout0_26 vdout0_26ck54 = 3.3 time = 550
* CHECK dout0_27 vdout0_27ck54 = 0 time = 550
* CHECK dout0_28 vdout0_28ck54 = 0 time = 550
* CHECK dout0_29 vdout0_29ck54 = 3.3 time = 550
* CHECK dout0_30 vdout0_30ck54 = 3.3 time = 550
* CHECK dout0_31 vdout0_31ck54 = 0 time = 550
* CHECK dout0_32 vdout0_32ck54 = 0 time = 550
* CHECK dout0_0 vdout0_0ck55 = 3.3 time = 560
* CHECK dout0_1 vdout0_1ck55 = 0 time = 560
* CHECK dout0_2 vdout0_2ck55 = 0 time = 560
* CHECK dout0_3 vdout0_3ck55 = 0 time = 560
* CHECK dout0_4 vdout0_4ck55 = 3.3 time = 560
* CHECK dout0_5 vdout0_5ck55 = 0 time = 560
* CHECK dout0_6 vdout0_6ck55 = 3.3 time = 560
* CHECK dout0_7 vdout0_7ck55 = 0 time = 560
* CHECK dout0_8 vdout0_8ck55 = 0 time = 560
* CHECK dout0_9 vdout0_9ck55 = 0 time = 560
* CHECK dout0_10 vdout0_10ck55 = 0 time = 560
* CHECK dout0_11 vdout0_11ck55 = 0 time = 560
* CHECK dout0_12 vdout0_12ck55 = 0 time = 560
* CHECK dout0_13 vdout0_13ck55 = 3.3 time = 560
* CHECK dout0_14 vdout0_14ck55 = 3.3 time = 560
* CHECK dout0_15 vdout0_15ck55 = 0 time = 560
* CHECK dout0_16 vdout0_16ck55 = 0 time = 560
* CHECK dout0_17 vdout0_17ck55 = 3.3 time = 560
* CHECK dout0_18 vdout0_18ck55 = 0 time = 560
* CHECK dout0_19 vdout0_19ck55 = 0 time = 560
* CHECK dout0_20 vdout0_20ck55 = 3.3 time = 560
* CHECK dout0_21 vdout0_21ck55 = 3.3 time = 560
* CHECK dout0_22 vdout0_22ck55 = 0 time = 560
* CHECK dout0_23 vdout0_23ck55 = 0 time = 560
* CHECK dout0_24 vdout0_24ck55 = 3.3 time = 560
* CHECK dout0_25 vdout0_25ck55 = 0 time = 560
* CHECK dout0_26 vdout0_26ck55 = 0 time = 560
* CHECK dout0_27 vdout0_27ck55 = 0 time = 560
* CHECK dout0_28 vdout0_28ck55 = 0 time = 560
* CHECK dout0_29 vdout0_29ck55 = 0 time = 560
* CHECK dout0_30 vdout0_30ck55 = 0 time = 560
* CHECK dout0_31 vdout0_31ck55 = 0 time = 560
* CHECK dout0_32 vdout0_32ck55 = 0 time = 560
* CHECK dout0_0 vdout0_0ck56 = 3.3 time = 570
* CHECK dout0_1 vdout0_1ck56 = 3.3 time = 570
* CHECK dout0_2 vdout0_2ck56 = 3.3 time = 570
* CHECK dout0_3 vdout0_3ck56 = 0 time = 570
* CHECK dout0_4 vdout0_4ck56 = 0 time = 570
* CHECK dout0_5 vdout0_5ck56 = 0 time = 570
* CHECK dout0_6 vdout0_6ck56 = 3.3 time = 570
* CHECK dout0_7 vdout0_7ck56 = 0 time = 570
* CHECK dout0_8 vdout0_8ck56 = 0 time = 570
* CHECK dout0_9 vdout0_9ck56 = 0 time = 570
* CHECK dout0_10 vdout0_10ck56 = 3.3 time = 570
* CHECK dout0_11 vdout0_11ck56 = 0 time = 570
* CHECK dout0_12 vdout0_12ck56 = 3.3 time = 570
* CHECK dout0_13 vdout0_13ck56 = 0 time = 570
* CHECK dout0_14 vdout0_14ck56 = 3.3 time = 570
* CHECK dout0_15 vdout0_15ck56 = 0 time = 570
* CHECK dout0_16 vdout0_16ck56 = 3.3 time = 570
* CHECK dout0_17 vdout0_17ck56 = 3.3 time = 570
* CHECK dout0_18 vdout0_18ck56 = 0 time = 570
* CHECK dout0_19 vdout0_19ck56 = 3.3 time = 570
* CHECK dout0_20 vdout0_20ck56 = 0 time = 570
* CHECK dout0_21 vdout0_21ck56 = 3.3 time = 570
* CHECK dout0_22 vdout0_22ck56 = 0 time = 570
* CHECK dout0_23 vdout0_23ck56 = 3.3 time = 570
* CHECK dout0_24 vdout0_24ck56 = 3.3 time = 570
* CHECK dout0_25 vdout0_25ck56 = 0 time = 570
* CHECK dout0_26 vdout0_26ck56 = 3.3 time = 570
* CHECK dout0_27 vdout0_27ck56 = 0 time = 570
* CHECK dout0_28 vdout0_28ck56 = 0 time = 570
* CHECK dout0_29 vdout0_29ck56 = 3.3 time = 570
* CHECK dout0_30 vdout0_30ck56 = 3.3 time = 570
* CHECK dout0_31 vdout0_31ck56 = 0 time = 570
* CHECK dout0_32 vdout0_32ck56 = 0 time = 570
* CHECK dout0_0 vdout0_0ck58 = 3.3 time = 590
* CHECK dout0_1 vdout0_1ck58 = 3.3 time = 590
* CHECK dout0_2 vdout0_2ck58 = 3.3 time = 590
* CHECK dout0_3 vdout0_3ck58 = 0 time = 590
* CHECK dout0_4 vdout0_4ck58 = 0 time = 590
* CHECK dout0_5 vdout0_5ck58 = 0 time = 590
* CHECK dout0_6 vdout0_6ck58 = 3.3 time = 590
* CHECK dout0_7 vdout0_7ck58 = 0 time = 590
* CHECK dout0_8 vdout0_8ck58 = 0 time = 590
* CHECK dout0_9 vdout0_9ck58 = 0 time = 590
* CHECK dout0_10 vdout0_10ck58 = 3.3 time = 590
* CHECK dout0_11 vdout0_11ck58 = 0 time = 590
* CHECK dout0_12 vdout0_12ck58 = 3.3 time = 590
* CHECK dout0_13 vdout0_13ck58 = 0 time = 590
* CHECK dout0_14 vdout0_14ck58 = 3.3 time = 590
* CHECK dout0_15 vdout0_15ck58 = 0 time = 590
* CHECK dout0_16 vdout0_16ck58 = 3.3 time = 590
* CHECK dout0_17 vdout0_17ck58 = 3.3 time = 590
* CHECK dout0_18 vdout0_18ck58 = 0 time = 590
* CHECK dout0_19 vdout0_19ck58 = 3.3 time = 590
* CHECK dout0_20 vdout0_20ck58 = 0 time = 590
* CHECK dout0_21 vdout0_21ck58 = 3.3 time = 590
* CHECK dout0_22 vdout0_22ck58 = 0 time = 590
* CHECK dout0_23 vdout0_23ck58 = 3.3 time = 590
* CHECK dout0_24 vdout0_24ck58 = 3.3 time = 590
* CHECK dout0_25 vdout0_25ck58 = 0 time = 590
* CHECK dout0_26 vdout0_26ck58 = 3.3 time = 590
* CHECK dout0_27 vdout0_27ck58 = 0 time = 590
* CHECK dout0_28 vdout0_28ck58 = 0 time = 590
* CHECK dout0_29 vdout0_29ck58 = 3.3 time = 590
* CHECK dout0_30 vdout0_30ck58 = 3.3 time = 590
* CHECK dout0_31 vdout0_31ck58 = 0 time = 590
* CHECK dout0_32 vdout0_32ck58 = 0 time = 590
* CHECK dout0_0 vdout0_0ck59 = 3.3 time = 600
* CHECK dout0_1 vdout0_1ck59 = 3.3 time = 600
* CHECK dout0_2 vdout0_2ck59 = 3.3 time = 600
* CHECK dout0_3 vdout0_3ck59 = 0 time = 600
* CHECK dout0_4 vdout0_4ck59 = 0 time = 600
* CHECK dout0_5 vdout0_5ck59 = 0 time = 600
* CHECK dout0_6 vdout0_6ck59 = 3.3 time = 600
* CHECK dout0_7 vdout0_7ck59 = 0 time = 600
* CHECK dout0_8 vdout0_8ck59 = 0 time = 600
* CHECK dout0_9 vdout0_9ck59 = 0 time = 600
* CHECK dout0_10 vdout0_10ck59 = 3.3 time = 600
* CHECK dout0_11 vdout0_11ck59 = 0 time = 600
* CHECK dout0_12 vdout0_12ck59 = 3.3 time = 600
* CHECK dout0_13 vdout0_13ck59 = 0 time = 600
* CHECK dout0_14 vdout0_14ck59 = 3.3 time = 600
* CHECK dout0_15 vdout0_15ck59 = 0 time = 600
* CHECK dout0_16 vdout0_16ck59 = 3.3 time = 600
* CHECK dout0_17 vdout0_17ck59 = 3.3 time = 600
* CHECK dout0_18 vdout0_18ck59 = 0 time = 600
* CHECK dout0_19 vdout0_19ck59 = 3.3 time = 600
* CHECK dout0_20 vdout0_20ck59 = 0 time = 600
* CHECK dout0_21 vdout0_21ck59 = 3.3 time = 600
* CHECK dout0_22 vdout0_22ck59 = 0 time = 600
* CHECK dout0_23 vdout0_23ck59 = 3.3 time = 600
* CHECK dout0_24 vdout0_24ck59 = 3.3 time = 600
* CHECK dout0_25 vdout0_25ck59 = 0 time = 600
* CHECK dout0_26 vdout0_26ck59 = 3.3 time = 600
* CHECK dout0_27 vdout0_27ck59 = 0 time = 600
* CHECK dout0_28 vdout0_28ck59 = 0 time = 600
* CHECK dout0_29 vdout0_29ck59 = 3.3 time = 600
* CHECK dout0_30 vdout0_30ck59 = 3.3 time = 600
* CHECK dout0_31 vdout0_31ck59 = 0 time = 600
* CHECK dout0_32 vdout0_32ck59 = 0 time = 600
* CHECK dout0_0 vdout0_0ck60 = 0 time = 610
* CHECK dout0_1 vdout0_1ck60 = 0 time = 610
* CHECK dout0_2 vdout0_2ck60 = 0 time = 610
* CHECK dout0_3 vdout0_3ck60 = 0 time = 610
* CHECK dout0_4 vdout0_4ck60 = 0 time = 610
* CHECK dout0_5 vdout0_5ck60 = 0 time = 610
* CHECK dout0_6 vdout0_6ck60 = 3.3 time = 610
* CHECK dout0_7 vdout0_7ck60 = 0 time = 610
* CHECK dout0_8 vdout0_8ck60 = 0 time = 610
* CHECK dout0_9 vdout0_9ck60 = 0 time = 610
* CHECK dout0_10 vdout0_10ck60 = 3.3 time = 610
* CHECK dout0_11 vdout0_11ck60 = 3.3 time = 610
* CHECK dout0_12 vdout0_12ck60 = 3.3 time = 610
* CHECK dout0_13 vdout0_13ck60 = 0 time = 610
* CHECK dout0_14 vdout0_14ck60 = 3.3 time = 610
* CHECK dout0_15 vdout0_15ck60 = 0 time = 610
* CHECK dout0_16 vdout0_16ck60 = 0 time = 610
* CHECK dout0_17 vdout0_17ck60 = 3.3 time = 610
* CHECK dout0_18 vdout0_18ck60 = 3.3 time = 610
* CHECK dout0_19 vdout0_19ck60 = 0 time = 610
* CHECK dout0_20 vdout0_20ck60 = 0 time = 610
* CHECK dout0_21 vdout0_21ck60 = 3.3 time = 610
* CHECK dout0_22 vdout0_22ck60 = 0 time = 610
* CHECK dout0_23 vdout0_23ck60 = 3.3 time = 610
* CHECK dout0_24 vdout0_24ck60 = 3.3 time = 610
* CHECK dout0_25 vdout0_25ck60 = 3.3 time = 610
* CHECK dout0_26 vdout0_26ck60 = 0 time = 610
* CHECK dout0_27 vdout0_27ck60 = 3.3 time = 610
* CHECK dout0_28 vdout0_28ck60 = 0 time = 610
* CHECK dout0_29 vdout0_29ck60 = 0 time = 610
* CHECK dout0_30 vdout0_30ck60 = 0 time = 610
* CHECK dout0_31 vdout0_31ck60 = 3.3 time = 610
* CHECK dout0_32 vdout0_32ck60 = 0 time = 610
* CHECK dout0_0 vdout0_0ck62 = 3.3 time = 630
* CHECK dout0_1 vdout0_1ck62 = 3.3 time = 630
* CHECK dout0_2 vdout0_2ck62 = 3.3 time = 630
* CHECK dout0_3 vdout0_3ck62 = 0 time = 630
* CHECK dout0_4 vdout0_4ck62 = 0 time = 630
* CHECK dout0_5 vdout0_5ck62 = 0 time = 630
* CHECK dout0_6 vdout0_6ck62 = 3.3 time = 630
* CHECK dout0_7 vdout0_7ck62 = 0 time = 630
* CHECK dout0_8 vdout0_8ck62 = 0 time = 630
* CHECK dout0_9 vdout0_9ck62 = 0 time = 630
* CHECK dout0_10 vdout0_10ck62 = 3.3 time = 630
* CHECK dout0_11 vdout0_11ck62 = 0 time = 630
* CHECK dout0_12 vdout0_12ck62 = 3.3 time = 630
* CHECK dout0_13 vdout0_13ck62 = 0 time = 630
* CHECK dout0_14 vdout0_14ck62 = 3.3 time = 630
* CHECK dout0_15 vdout0_15ck62 = 0 time = 630
* CHECK dout0_16 vdout0_16ck62 = 3.3 time = 630
* CHECK dout0_17 vdout0_17ck62 = 3.3 time = 630
* CHECK dout0_18 vdout0_18ck62 = 0 time = 630
* CHECK dout0_19 vdout0_19ck62 = 3.3 time = 630
* CHECK dout0_20 vdout0_20ck62 = 0 time = 630
* CHECK dout0_21 vdout0_21ck62 = 3.3 time = 630
* CHECK dout0_22 vdout0_22ck62 = 0 time = 630
* CHECK dout0_23 vdout0_23ck62 = 3.3 time = 630
* CHECK dout0_24 vdout0_24ck62 = 3.3 time = 630
* CHECK dout0_25 vdout0_25ck62 = 0 time = 630
* CHECK dout0_26 vdout0_26ck62 = 3.3 time = 630
* CHECK dout0_27 vdout0_27ck62 = 0 time = 630
* CHECK dout0_28 vdout0_28ck62 = 0 time = 630
* CHECK dout0_29 vdout0_29ck62 = 3.3 time = 630
* CHECK dout0_30 vdout0_30ck62 = 3.3 time = 630
* CHECK dout0_31 vdout0_31ck62 = 0 time = 630
* CHECK dout0_32 vdout0_32ck62 = 0 time = 630
* CHECK dout0_0 vdout0_0ck69 = 3.3 time = 700
* CHECK dout0_1 vdout0_1ck69 = 3.3 time = 700
* CHECK dout0_2 vdout0_2ck69 = 0 time = 700
* CHECK dout0_3 vdout0_3ck69 = 3.3 time = 700
* CHECK dout0_4 vdout0_4ck69 = 3.3 time = 700
* CHECK dout0_5 vdout0_5ck69 = 0 time = 700
* CHECK dout0_6 vdout0_6ck69 = 3.3 time = 700
* CHECK dout0_7 vdout0_7ck69 = 0 time = 700
* CHECK dout0_8 vdout0_8ck69 = 0 time = 700
* CHECK dout0_9 vdout0_9ck69 = 0 time = 700
* CHECK dout0_10 vdout0_10ck69 = 0 time = 700
* CHECK dout0_11 vdout0_11ck69 = 3.3 time = 700
* CHECK dout0_12 vdout0_12ck69 = 0 time = 700
* CHECK dout0_13 vdout0_13ck69 = 3.3 time = 700
* CHECK dout0_14 vdout0_14ck69 = 0 time = 700
* CHECK dout0_15 vdout0_15ck69 = 0 time = 700
* CHECK dout0_16 vdout0_16ck69 = 3.3 time = 700
* CHECK dout0_17 vdout0_17ck69 = 0 time = 700
* CHECK dout0_18 vdout0_18ck69 = 3.3 time = 700
* CHECK dout0_19 vdout0_19ck69 = 0 time = 700
* CHECK dout0_20 vdout0_20ck69 = 3.3 time = 700
* CHECK dout0_21 vdout0_21ck69 = 3.3 time = 700
* CHECK dout0_22 vdout0_22ck69 = 3.3 time = 700
* CHECK dout0_23 vdout0_23ck69 = 0 time = 700
* CHECK dout0_24 vdout0_24ck69 = 0 time = 700
* CHECK dout0_25 vdout0_25ck69 = 0 time = 700
* CHECK dout0_26 vdout0_26ck69 = 0 time = 700
* CHECK dout0_27 vdout0_27ck69 = 3.3 time = 700
* CHECK dout0_28 vdout0_28ck69 = 0 time = 700
* CHECK dout0_29 vdout0_29ck69 = 0 time = 700
* CHECK dout0_30 vdout0_30ck69 = 0 time = 700
* CHECK dout0_31 vdout0_31ck69 = 3.3 time = 700
* CHECK dout0_32 vdout0_32ck69 = 0 time = 700
* CHECK dout0_0 vdout0_0ck70 = 3.3 time = 710
* CHECK dout0_1 vdout0_1ck70 = 0 time = 710
* CHECK dout0_2 vdout0_2ck70 = 3.3 time = 710
* CHECK dout0_3 vdout0_3ck70 = 3.3 time = 710
* CHECK dout0_4 vdout0_4ck70 = 3.3 time = 710
* CHECK dout0_5 vdout0_5ck70 = 3.3 time = 710
* CHECK dout0_6 vdout0_6ck70 = 3.3 time = 710
* CHECK dout0_7 vdout0_7ck70 = 3.3 time = 710
* CHECK dout0_8 vdout0_8ck70 = 0 time = 710
* CHECK dout0_9 vdout0_9ck70 = 3.3 time = 710
* CHECK dout0_10 vdout0_10ck70 = 0 time = 710
* CHECK dout0_11 vdout0_11ck70 = 0 time = 710
* CHECK dout0_12 vdout0_12ck70 = 3.3 time = 710
* CHECK dout0_13 vdout0_13ck70 = 0 time = 710
* CHECK dout0_14 vdout0_14ck70 = 0 time = 710
* CHECK dout0_15 vdout0_15ck70 = 3.3 time = 710
* CHECK dout0_16 vdout0_16ck70 = 3.3 time = 710
* CHECK dout0_17 vdout0_17ck70 = 0 time = 710
* CHECK dout0_18 vdout0_18ck70 = 3.3 time = 710
* CHECK dout0_19 vdout0_19ck70 = 3.3 time = 710
* CHECK dout0_20 vdout0_20ck70 = 3.3 time = 710
* CHECK dout0_21 vdout0_21ck70 = 0 time = 710
* CHECK dout0_22 vdout0_22ck70 = 0 time = 710
* CHECK dout0_23 vdout0_23ck70 = 3.3 time = 710
* CHECK dout0_24 vdout0_24ck70 = 0 time = 710
* CHECK dout0_25 vdout0_25ck70 = 0 time = 710
* CHECK dout0_26 vdout0_26ck70 = 3.3 time = 710
* CHECK dout0_27 vdout0_27ck70 = 3.3 time = 710
* CHECK dout0_28 vdout0_28ck70 = 0 time = 710
* CHECK dout0_29 vdout0_29ck70 = 0 time = 710
* CHECK dout0_30 vdout0_30ck70 = 0 time = 710
* CHECK dout0_31 vdout0_31ck70 = 0 time = 710
* CHECK dout0_32 vdout0_32ck70 = 0 time = 710
* CHECK dout0_0 vdout0_0ck71 = 3.3 time = 720
* CHECK dout0_1 vdout0_1ck71 = 3.3 time = 720
* CHECK dout0_2 vdout0_2ck71 = 0 time = 720
* CHECK dout0_3 vdout0_3ck71 = 3.3 time = 720
* CHECK dout0_4 vdout0_4ck71 = 3.3 time = 720
* CHECK dout0_5 vdout0_5ck71 = 0 time = 720
* CHECK dout0_6 vdout0_6ck71 = 3.3 time = 720
* CHECK dout0_7 vdout0_7ck71 = 0 time = 720
* CHECK dout0_8 vdout0_8ck71 = 0 time = 720
* CHECK dout0_9 vdout0_9ck71 = 0 time = 720
* CHECK dout0_10 vdout0_10ck71 = 0 time = 720
* CHECK dout0_11 vdout0_11ck71 = 3.3 time = 720
* CHECK dout0_12 vdout0_12ck71 = 0 time = 720
* CHECK dout0_13 vdout0_13ck71 = 3.3 time = 720
* CHECK dout0_14 vdout0_14ck71 = 0 time = 720
* CHECK dout0_15 vdout0_15ck71 = 0 time = 720
* CHECK dout0_16 vdout0_16ck71 = 3.3 time = 720
* CHECK dout0_17 vdout0_17ck71 = 0 time = 720
* CHECK dout0_18 vdout0_18ck71 = 3.3 time = 720
* CHECK dout0_19 vdout0_19ck71 = 0 time = 720
* CHECK dout0_20 vdout0_20ck71 = 3.3 time = 720
* CHECK dout0_21 vdout0_21ck71 = 3.3 time = 720
* CHECK dout0_22 vdout0_22ck71 = 3.3 time = 720
* CHECK dout0_23 vdout0_23ck71 = 0 time = 720
* CHECK dout0_24 vdout0_24ck71 = 0 time = 720
* CHECK dout0_25 vdout0_25ck71 = 0 time = 720
* CHECK dout0_26 vdout0_26ck71 = 0 time = 720
* CHECK dout0_27 vdout0_27ck71 = 3.3 time = 720
* CHECK dout0_28 vdout0_28ck71 = 0 time = 720
* CHECK dout0_29 vdout0_29ck71 = 0 time = 720
* CHECK dout0_30 vdout0_30ck71 = 0 time = 720
* CHECK dout0_31 vdout0_31ck71 = 3.3 time = 720
* CHECK dout0_32 vdout0_32ck71 = 0 time = 720
* CHECK dout0_0 vdout0_0ck72 = 3.3 time = 730
* CHECK dout0_1 vdout0_1ck72 = 0 time = 730
* CHECK dout0_2 vdout0_2ck72 = 3.3 time = 730
* CHECK dout0_3 vdout0_3ck72 = 3.3 time = 730
* CHECK dout0_4 vdout0_4ck72 = 3.3 time = 730
* CHECK dout0_5 vdout0_5ck72 = 3.3 time = 730
* CHECK dout0_6 vdout0_6ck72 = 3.3 time = 730
* CHECK dout0_7 vdout0_7ck72 = 3.3 time = 730
* CHECK dout0_8 vdout0_8ck72 = 0 time = 730
* CHECK dout0_9 vdout0_9ck72 = 3.3 time = 730
* CHECK dout0_10 vdout0_10ck72 = 0 time = 730
* CHECK dout0_11 vdout0_11ck72 = 0 time = 730
* CHECK dout0_12 vdout0_12ck72 = 3.3 time = 730
* CHECK dout0_13 vdout0_13ck72 = 0 time = 730
* CHECK dout0_14 vdout0_14ck72 = 0 time = 730
* CHECK dout0_15 vdout0_15ck72 = 3.3 time = 730
* CHECK dout0_16 vdout0_16ck72 = 3.3 time = 730
* CHECK dout0_17 vdout0_17ck72 = 0 time = 730
* CHECK dout0_18 vdout0_18ck72 = 3.3 time = 730
* CHECK dout0_19 vdout0_19ck72 = 3.3 time = 730
* CHECK dout0_20 vdout0_20ck72 = 3.3 time = 730
* CHECK dout0_21 vdout0_21ck72 = 0 time = 730
* CHECK dout0_22 vdout0_22ck72 = 0 time = 730
* CHECK dout0_23 vdout0_23ck72 = 3.3 time = 730
* CHECK dout0_24 vdout0_24ck72 = 0 time = 730
* CHECK dout0_25 vdout0_25ck72 = 0 time = 730
* CHECK dout0_26 vdout0_26ck72 = 3.3 time = 730
* CHECK dout0_27 vdout0_27ck72 = 3.3 time = 730
* CHECK dout0_28 vdout0_28ck72 = 0 time = 730
* CHECK dout0_29 vdout0_29ck72 = 0 time = 730
* CHECK dout0_30 vdout0_30ck72 = 0 time = 730
* CHECK dout0_31 vdout0_31ck72 = 0 time = 730
* CHECK dout0_32 vdout0_32ck72 = 0 time = 730
* CHECK dout0_0 vdout0_0ck73 = 3.3 time = 740
* CHECK dout0_1 vdout0_1ck73 = 3.3 time = 740
* CHECK dout0_2 vdout0_2ck73 = 0 time = 740
* CHECK dout0_3 vdout0_3ck73 = 3.3 time = 740
* CHECK dout0_4 vdout0_4ck73 = 3.3 time = 740
* CHECK dout0_5 vdout0_5ck73 = 0 time = 740
* CHECK dout0_6 vdout0_6ck73 = 3.3 time = 740
* CHECK dout0_7 vdout0_7ck73 = 0 time = 740
* CHECK dout0_8 vdout0_8ck73 = 0 time = 740
* CHECK dout0_9 vdout0_9ck73 = 0 time = 740
* CHECK dout0_10 vdout0_10ck73 = 0 time = 740
* CHECK dout0_11 vdout0_11ck73 = 3.3 time = 740
* CHECK dout0_12 vdout0_12ck73 = 0 time = 740
* CHECK dout0_13 vdout0_13ck73 = 3.3 time = 740
* CHECK dout0_14 vdout0_14ck73 = 0 time = 740
* CHECK dout0_15 vdout0_15ck73 = 0 time = 740
* CHECK dout0_16 vdout0_16ck73 = 3.3 time = 740
* CHECK dout0_17 vdout0_17ck73 = 0 time = 740
* CHECK dout0_18 vdout0_18ck73 = 3.3 time = 740
* CHECK dout0_19 vdout0_19ck73 = 0 time = 740
* CHECK dout0_20 vdout0_20ck73 = 3.3 time = 740
* CHECK dout0_21 vdout0_21ck73 = 3.3 time = 740
* CHECK dout0_22 vdout0_22ck73 = 3.3 time = 740
* CHECK dout0_23 vdout0_23ck73 = 0 time = 740
* CHECK dout0_24 vdout0_24ck73 = 0 time = 740
* CHECK dout0_25 vdout0_25ck73 = 0 time = 740
* CHECK dout0_26 vdout0_26ck73 = 0 time = 740
* CHECK dout0_27 vdout0_27ck73 = 3.3 time = 740
* CHECK dout0_28 vdout0_28ck73 = 0 time = 740
* CHECK dout0_29 vdout0_29ck73 = 0 time = 740
* CHECK dout0_30 vdout0_30ck73 = 0 time = 740
* CHECK dout0_31 vdout0_31ck73 = 3.3 time = 740
* CHECK dout0_32 vdout0_32ck73 = 0 time = 740
* CHECK dout0_0 vdout0_0ck74 = 3.3 time = 750
* CHECK dout0_1 vdout0_1ck74 = 0 time = 750
* CHECK dout0_2 vdout0_2ck74 = 3.3 time = 750
* CHECK dout0_3 vdout0_3ck74 = 3.3 time = 750
* CHECK dout0_4 vdout0_4ck74 = 3.3 time = 750
* CHECK dout0_5 vdout0_5ck74 = 3.3 time = 750
* CHECK dout0_6 vdout0_6ck74 = 3.3 time = 750
* CHECK dout0_7 vdout0_7ck74 = 3.3 time = 750
* CHECK dout0_8 vdout0_8ck74 = 0 time = 750
* CHECK dout0_9 vdout0_9ck74 = 3.3 time = 750
* CHECK dout0_10 vdout0_10ck74 = 0 time = 750
* CHECK dout0_11 vdout0_11ck74 = 0 time = 750
* CHECK dout0_12 vdout0_12ck74 = 3.3 time = 750
* CHECK dout0_13 vdout0_13ck74 = 0 time = 750
* CHECK dout0_14 vdout0_14ck74 = 0 time = 750
* CHECK dout0_15 vdout0_15ck74 = 3.3 time = 750
* CHECK dout0_16 vdout0_16ck74 = 3.3 time = 750
* CHECK dout0_17 vdout0_17ck74 = 0 time = 750
* CHECK dout0_18 vdout0_18ck74 = 3.3 time = 750
* CHECK dout0_19 vdout0_19ck74 = 3.3 time = 750
* CHECK dout0_20 vdout0_20ck74 = 3.3 time = 750
* CHECK dout0_21 vdout0_21ck74 = 0 time = 750
* CHECK dout0_22 vdout0_22ck74 = 0 time = 750
* CHECK dout0_23 vdout0_23ck74 = 3.3 time = 750
* CHECK dout0_24 vdout0_24ck74 = 0 time = 750
* CHECK dout0_25 vdout0_25ck74 = 0 time = 750
* CHECK dout0_26 vdout0_26ck74 = 3.3 time = 750
* CHECK dout0_27 vdout0_27ck74 = 3.3 time = 750
* CHECK dout0_28 vdout0_28ck74 = 0 time = 750
* CHECK dout0_29 vdout0_29ck74 = 0 time = 750
* CHECK dout0_30 vdout0_30ck74 = 0 time = 750
* CHECK dout0_31 vdout0_31ck74 = 0 time = 750
* CHECK dout0_32 vdout0_32ck74 = 0 time = 750
* CHECK dout0_0 vdout0_0ck76 = 3.3 time = 770
* CHECK dout0_1 vdout0_1ck76 = 3.3 time = 770
* CHECK dout0_2 vdout0_2ck76 = 0 time = 770
* CHECK dout0_3 vdout0_3ck76 = 3.3 time = 770
* CHECK dout0_4 vdout0_4ck76 = 3.3 time = 770
* CHECK dout0_5 vdout0_5ck76 = 0 time = 770
* CHECK dout0_6 vdout0_6ck76 = 3.3 time = 770
* CHECK dout0_7 vdout0_7ck76 = 0 time = 770
* CHECK dout0_8 vdout0_8ck76 = 0 time = 770
* CHECK dout0_9 vdout0_9ck76 = 0 time = 770
* CHECK dout0_10 vdout0_10ck76 = 0 time = 770
* CHECK dout0_11 vdout0_11ck76 = 3.3 time = 770
* CHECK dout0_12 vdout0_12ck76 = 0 time = 770
* CHECK dout0_13 vdout0_13ck76 = 3.3 time = 770
* CHECK dout0_14 vdout0_14ck76 = 0 time = 770
* CHECK dout0_15 vdout0_15ck76 = 0 time = 770
* CHECK dout0_16 vdout0_16ck76 = 3.3 time = 770
* CHECK dout0_17 vdout0_17ck76 = 0 time = 770
* CHECK dout0_18 vdout0_18ck76 = 3.3 time = 770
* CHECK dout0_19 vdout0_19ck76 = 0 time = 770
* CHECK dout0_20 vdout0_20ck76 = 3.3 time = 770
* CHECK dout0_21 vdout0_21ck76 = 3.3 time = 770
* CHECK dout0_22 vdout0_22ck76 = 3.3 time = 770
* CHECK dout0_23 vdout0_23ck76 = 0 time = 770
* CHECK dout0_24 vdout0_24ck76 = 0 time = 770
* CHECK dout0_25 vdout0_25ck76 = 0 time = 770
* CHECK dout0_26 vdout0_26ck76 = 0 time = 770
* CHECK dout0_27 vdout0_27ck76 = 3.3 time = 770
* CHECK dout0_28 vdout0_28ck76 = 0 time = 770
* CHECK dout0_29 vdout0_29ck76 = 0 time = 770
* CHECK dout0_30 vdout0_30ck76 = 0 time = 770
* CHECK dout0_31 vdout0_31ck76 = 3.3 time = 770
* CHECK dout0_32 vdout0_32ck76 = 0 time = 770
* CHECK dout0_0 vdout0_0ck77 = 0 time = 780
* CHECK dout0_1 vdout0_1ck77 = 0 time = 780
* CHECK dout0_2 vdout0_2ck77 = 3.3 time = 780
* CHECK dout0_3 vdout0_3ck77 = 3.3 time = 780
* CHECK dout0_4 vdout0_4ck77 = 0 time = 780
* CHECK dout0_5 vdout0_5ck77 = 0 time = 780
* CHECK dout0_6 vdout0_6ck77 = 0 time = 780
* CHECK dout0_7 vdout0_7ck77 = 3.3 time = 780
* CHECK dout0_8 vdout0_8ck77 = 3.3 time = 780
* CHECK dout0_9 vdout0_9ck77 = 0 time = 780
* CHECK dout0_10 vdout0_10ck77 = 0 time = 780
* CHECK dout0_11 vdout0_11ck77 = 3.3 time = 780
* CHECK dout0_12 vdout0_12ck77 = 3.3 time = 780
* CHECK dout0_13 vdout0_13ck77 = 3.3 time = 780
* CHECK dout0_14 vdout0_14ck77 = 0 time = 780
* CHECK dout0_15 vdout0_15ck77 = 3.3 time = 780
* CHECK dout0_16 vdout0_16ck77 = 3.3 time = 780
* CHECK dout0_17 vdout0_17ck77 = 0 time = 780
* CHECK dout0_18 vdout0_18ck77 = 3.3 time = 780
* CHECK dout0_19 vdout0_19ck77 = 3.3 time = 780
* CHECK dout0_20 vdout0_20ck77 = 0 time = 780
* CHECK dout0_21 vdout0_21ck77 = 0 time = 780
* CHECK dout0_22 vdout0_22ck77 = 3.3 time = 780
* CHECK dout0_23 vdout0_23ck77 = 0 time = 780
* CHECK dout0_24 vdout0_24ck77 = 3.3 time = 780
* CHECK dout0_25 vdout0_25ck77 = 0 time = 780
* CHECK dout0_26 vdout0_26ck77 = 0 time = 780
* CHECK dout0_27 vdout0_27ck77 = 3.3 time = 780
* CHECK dout0_28 vdout0_28ck77 = 0 time = 780
* CHECK dout0_29 vdout0_29ck77 = 0 time = 780
* CHECK dout0_30 vdout0_30ck77 = 0 time = 780
* CHECK dout0_31 vdout0_31ck77 = 3.3 time = 780
* CHECK dout0_32 vdout0_32ck77 = 0 time = 780
* CHECK dout0_0 vdout0_0ck80 = 0 time = 810
* CHECK dout0_1 vdout0_1ck80 = 0 time = 810
* CHECK dout0_2 vdout0_2ck80 = 3.3 time = 810
* CHECK dout0_3 vdout0_3ck80 = 3.3 time = 810
* CHECK dout0_4 vdout0_4ck80 = 0 time = 810
* CHECK dout0_5 vdout0_5ck80 = 0 time = 810
* CHECK dout0_6 vdout0_6ck80 = 0 time = 810
* CHECK dout0_7 vdout0_7ck80 = 3.3 time = 810
* CHECK dout0_8 vdout0_8ck80 = 3.3 time = 810
* CHECK dout0_9 vdout0_9ck80 = 0 time = 810
* CHECK dout0_10 vdout0_10ck80 = 0 time = 810
* CHECK dout0_11 vdout0_11ck80 = 3.3 time = 810
* CHECK dout0_12 vdout0_12ck80 = 3.3 time = 810
* CHECK dout0_13 vdout0_13ck80 = 3.3 time = 810
* CHECK dout0_14 vdout0_14ck80 = 0 time = 810
* CHECK dout0_15 vdout0_15ck80 = 3.3 time = 810
* CHECK dout0_16 vdout0_16ck80 = 3.3 time = 810
* CHECK dout0_17 vdout0_17ck80 = 0 time = 810
* CHECK dout0_18 vdout0_18ck80 = 3.3 time = 810
* CHECK dout0_19 vdout0_19ck80 = 3.3 time = 810
* CHECK dout0_20 vdout0_20ck80 = 0 time = 810
* CHECK dout0_21 vdout0_21ck80 = 0 time = 810
* CHECK dout0_22 vdout0_22ck80 = 3.3 time = 810
* CHECK dout0_23 vdout0_23ck80 = 0 time = 810
* CHECK dout0_24 vdout0_24ck80 = 3.3 time = 810
* CHECK dout0_25 vdout0_25ck80 = 0 time = 810
* CHECK dout0_26 vdout0_26ck80 = 0 time = 810
* CHECK dout0_27 vdout0_27ck80 = 3.3 time = 810
* CHECK dout0_28 vdout0_28ck80 = 0 time = 810
* CHECK dout0_29 vdout0_29ck80 = 0 time = 810
* CHECK dout0_30 vdout0_30ck80 = 0 time = 810
* CHECK dout0_31 vdout0_31ck80 = 3.3 time = 810
* CHECK dout0_32 vdout0_32ck80 = 0 time = 810
* CHECK dout0_0 vdout0_0ck81 = 3.3 time = 820
* CHECK dout0_1 vdout0_1ck81 = 3.3 time = 820
* CHECK dout0_2 vdout0_2ck81 = 0 time = 820
* CHECK dout0_3 vdout0_3ck81 = 3.3 time = 820
* CHECK dout0_4 vdout0_4ck81 = 3.3 time = 820
* CHECK dout0_5 vdout0_5ck81 = 0 time = 820
* CHECK dout0_6 vdout0_6ck81 = 3.3 time = 820
* CHECK dout0_7 vdout0_7ck81 = 0 time = 820
* CHECK dout0_8 vdout0_8ck81 = 0 time = 820
* CHECK dout0_9 vdout0_9ck81 = 0 time = 820
* CHECK dout0_10 vdout0_10ck81 = 0 time = 820
* CHECK dout0_11 vdout0_11ck81 = 3.3 time = 820
* CHECK dout0_12 vdout0_12ck81 = 0 time = 820
* CHECK dout0_13 vdout0_13ck81 = 3.3 time = 820
* CHECK dout0_14 vdout0_14ck81 = 0 time = 820
* CHECK dout0_15 vdout0_15ck81 = 0 time = 820
* CHECK dout0_16 vdout0_16ck81 = 3.3 time = 820
* CHECK dout0_17 vdout0_17ck81 = 0 time = 820
* CHECK dout0_18 vdout0_18ck81 = 3.3 time = 820
* CHECK dout0_19 vdout0_19ck81 = 0 time = 820
* CHECK dout0_20 vdout0_20ck81 = 3.3 time = 820
* CHECK dout0_21 vdout0_21ck81 = 3.3 time = 820
* CHECK dout0_22 vdout0_22ck81 = 3.3 time = 820
* CHECK dout0_23 vdout0_23ck81 = 0 time = 820
* CHECK dout0_24 vdout0_24ck81 = 0 time = 820
* CHECK dout0_25 vdout0_25ck81 = 0 time = 820
* CHECK dout0_26 vdout0_26ck81 = 0 time = 820
* CHECK dout0_27 vdout0_27ck81 = 3.3 time = 820
* CHECK dout0_28 vdout0_28ck81 = 0 time = 820
* CHECK dout0_29 vdout0_29ck81 = 0 time = 820
* CHECK dout0_30 vdout0_30ck81 = 0 time = 820
* CHECK dout0_31 vdout0_31ck81 = 3.3 time = 820
* CHECK dout0_32 vdout0_32ck81 = 0 time = 820
* CHECK dout0_0 vdout0_0ck82 = 0 time = 830
* CHECK dout0_1 vdout0_1ck82 = 0 time = 830
* CHECK dout0_2 vdout0_2ck82 = 3.3 time = 830
* CHECK dout0_3 vdout0_3ck82 = 3.3 time = 830
* CHECK dout0_4 vdout0_4ck82 = 0 time = 830
* CHECK dout0_5 vdout0_5ck82 = 0 time = 830
* CHECK dout0_6 vdout0_6ck82 = 0 time = 830
* CHECK dout0_7 vdout0_7ck82 = 3.3 time = 830
* CHECK dout0_8 vdout0_8ck82 = 3.3 time = 830
* CHECK dout0_9 vdout0_9ck82 = 0 time = 830
* CHECK dout0_10 vdout0_10ck82 = 0 time = 830
* CHECK dout0_11 vdout0_11ck82 = 3.3 time = 830
* CHECK dout0_12 vdout0_12ck82 = 3.3 time = 830
* CHECK dout0_13 vdout0_13ck82 = 3.3 time = 830
* CHECK dout0_14 vdout0_14ck82 = 0 time = 830
* CHECK dout0_15 vdout0_15ck82 = 3.3 time = 830
* CHECK dout0_16 vdout0_16ck82 = 3.3 time = 830
* CHECK dout0_17 vdout0_17ck82 = 0 time = 830
* CHECK dout0_18 vdout0_18ck82 = 3.3 time = 830
* CHECK dout0_19 vdout0_19ck82 = 3.3 time = 830
* CHECK dout0_20 vdout0_20ck82 = 0 time = 830
* CHECK dout0_21 vdout0_21ck82 = 0 time = 830
* CHECK dout0_22 vdout0_22ck82 = 3.3 time = 830
* CHECK dout0_23 vdout0_23ck82 = 0 time = 830
* CHECK dout0_24 vdout0_24ck82 = 3.3 time = 830
* CHECK dout0_25 vdout0_25ck82 = 0 time = 830
* CHECK dout0_26 vdout0_26ck82 = 0 time = 830
* CHECK dout0_27 vdout0_27ck82 = 3.3 time = 830
* CHECK dout0_28 vdout0_28ck82 = 0 time = 830
* CHECK dout0_29 vdout0_29ck82 = 0 time = 830
* CHECK dout0_30 vdout0_30ck82 = 0 time = 830
* CHECK dout0_31 vdout0_31ck82 = 3.3 time = 830
* CHECK dout0_32 vdout0_32ck82 = 0 time = 830
* CHECK dout0_0 vdout0_0ck83 = 0 time = 840
* CHECK dout0_1 vdout0_1ck83 = 0 time = 840
* CHECK dout0_2 vdout0_2ck83 = 3.3 time = 840
* CHECK dout0_3 vdout0_3ck83 = 3.3 time = 840
* CHECK dout0_4 vdout0_4ck83 = 0 time = 840
* CHECK dout0_5 vdout0_5ck83 = 0 time = 840
* CHECK dout0_6 vdout0_6ck83 = 0 time = 840
* CHECK dout0_7 vdout0_7ck83 = 3.3 time = 840
* CHECK dout0_8 vdout0_8ck83 = 3.3 time = 840
* CHECK dout0_9 vdout0_9ck83 = 0 time = 840
* CHECK dout0_10 vdout0_10ck83 = 0 time = 840
* CHECK dout0_11 vdout0_11ck83 = 3.3 time = 840
* CHECK dout0_12 vdout0_12ck83 = 3.3 time = 840
* CHECK dout0_13 vdout0_13ck83 = 3.3 time = 840
* CHECK dout0_14 vdout0_14ck83 = 0 time = 840
* CHECK dout0_15 vdout0_15ck83 = 3.3 time = 840
* CHECK dout0_16 vdout0_16ck83 = 3.3 time = 840
* CHECK dout0_17 vdout0_17ck83 = 0 time = 840
* CHECK dout0_18 vdout0_18ck83 = 3.3 time = 840
* CHECK dout0_19 vdout0_19ck83 = 3.3 time = 840
* CHECK dout0_20 vdout0_20ck83 = 0 time = 840
* CHECK dout0_21 vdout0_21ck83 = 0 time = 840
* CHECK dout0_22 vdout0_22ck83 = 3.3 time = 840
* CHECK dout0_23 vdout0_23ck83 = 0 time = 840
* CHECK dout0_24 vdout0_24ck83 = 3.3 time = 840
* CHECK dout0_25 vdout0_25ck83 = 0 time = 840
* CHECK dout0_26 vdout0_26ck83 = 0 time = 840
* CHECK dout0_27 vdout0_27ck83 = 3.3 time = 840
* CHECK dout0_28 vdout0_28ck83 = 0 time = 840
* CHECK dout0_29 vdout0_29ck83 = 0 time = 840
* CHECK dout0_30 vdout0_30ck83 = 0 time = 840
* CHECK dout0_31 vdout0_31ck83 = 3.3 time = 840
* CHECK dout0_32 vdout0_32ck83 = 0 time = 840
* CHECK dout0_0 vdout0_0ck86 = 3.3 time = 870
* CHECK dout0_1 vdout0_1ck86 = 3.3 time = 870
* CHECK dout0_2 vdout0_2ck86 = 3.3 time = 870
* CHECK dout0_3 vdout0_3ck86 = 3.3 time = 870
* CHECK dout0_4 vdout0_4ck86 = 0 time = 870
* CHECK dout0_5 vdout0_5ck86 = 3.3 time = 870
* CHECK dout0_6 vdout0_6ck86 = 0 time = 870
* CHECK dout0_7 vdout0_7ck86 = 3.3 time = 870
* CHECK dout0_8 vdout0_8ck86 = 0 time = 870
* CHECK dout0_9 vdout0_9ck86 = 3.3 time = 870
* CHECK dout0_10 vdout0_10ck86 = 0 time = 870
* CHECK dout0_11 vdout0_11ck86 = 0 time = 870
* CHECK dout0_12 vdout0_12ck86 = 3.3 time = 870
* CHECK dout0_13 vdout0_13ck86 = 0 time = 870
* CHECK dout0_14 vdout0_14ck86 = 0 time = 870
* CHECK dout0_15 vdout0_15ck86 = 3.3 time = 870
* CHECK dout0_16 vdout0_16ck86 = 0 time = 870
* CHECK dout0_17 vdout0_17ck86 = 3.3 time = 870
* CHECK dout0_18 vdout0_18ck86 = 3.3 time = 870
* CHECK dout0_19 vdout0_19ck86 = 0 time = 870
* CHECK dout0_20 vdout0_20ck86 = 3.3 time = 870
* CHECK dout0_21 vdout0_21ck86 = 3.3 time = 870
* CHECK dout0_22 vdout0_22ck86 = 0 time = 870
* CHECK dout0_23 vdout0_23ck86 = 0 time = 870
* CHECK dout0_24 vdout0_24ck86 = 0 time = 870
* CHECK dout0_25 vdout0_25ck86 = 0 time = 870
* CHECK dout0_26 vdout0_26ck86 = 0 time = 870
* CHECK dout0_27 vdout0_27ck86 = 3.3 time = 870
* CHECK dout0_28 vdout0_28ck86 = 0 time = 870
* CHECK dout0_29 vdout0_29ck86 = 3.3 time = 870
* CHECK dout0_30 vdout0_30ck86 = 3.3 time = 870
* CHECK dout0_31 vdout0_31ck86 = 0 time = 870
* CHECK dout0_32 vdout0_32ck86 = 0 time = 870
* CHECK dout0_0 vdout0_0ck87 = 3.3 time = 880
* CHECK dout0_1 vdout0_1ck87 = 3.3 time = 880
* CHECK dout0_2 vdout0_2ck87 = 0 time = 880
* CHECK dout0_3 vdout0_3ck87 = 3.3 time = 880
* CHECK dout0_4 vdout0_4ck87 = 3.3 time = 880
* CHECK dout0_5 vdout0_5ck87 = 0 time = 880
* CHECK dout0_6 vdout0_6ck87 = 3.3 time = 880
* CHECK dout0_7 vdout0_7ck87 = 0 time = 880
* CHECK dout0_8 vdout0_8ck87 = 0 time = 880
* CHECK dout0_9 vdout0_9ck87 = 0 time = 880
* CHECK dout0_10 vdout0_10ck87 = 0 time = 880
* CHECK dout0_11 vdout0_11ck87 = 3.3 time = 880
* CHECK dout0_12 vdout0_12ck87 = 0 time = 880
* CHECK dout0_13 vdout0_13ck87 = 3.3 time = 880
* CHECK dout0_14 vdout0_14ck87 = 0 time = 880
* CHECK dout0_15 vdout0_15ck87 = 0 time = 880
* CHECK dout0_16 vdout0_16ck87 = 3.3 time = 880
* CHECK dout0_17 vdout0_17ck87 = 0 time = 880
* CHECK dout0_18 vdout0_18ck87 = 3.3 time = 880
* CHECK dout0_19 vdout0_19ck87 = 0 time = 880
* CHECK dout0_20 vdout0_20ck87 = 3.3 time = 880
* CHECK dout0_21 vdout0_21ck87 = 3.3 time = 880
* CHECK dout0_22 vdout0_22ck87 = 3.3 time = 880
* CHECK dout0_23 vdout0_23ck87 = 0 time = 880
* CHECK dout0_24 vdout0_24ck87 = 0 time = 880
* CHECK dout0_25 vdout0_25ck87 = 0 time = 880
* CHECK dout0_26 vdout0_26ck87 = 0 time = 880
* CHECK dout0_27 vdout0_27ck87 = 3.3 time = 880
* CHECK dout0_28 vdout0_28ck87 = 0 time = 880
* CHECK dout0_29 vdout0_29ck87 = 0 time = 880
* CHECK dout0_30 vdout0_30ck87 = 0 time = 880
* CHECK dout0_31 vdout0_31ck87 = 3.3 time = 880
* CHECK dout0_32 vdout0_32ck87 = 0 time = 880
* CHECK dout0_0 vdout0_0ck90 = 3.3 time = 910
* CHECK dout0_1 vdout0_1ck90 = 3.3 time = 910
* CHECK dout0_2 vdout0_2ck90 = 0 time = 910
* CHECK dout0_3 vdout0_3ck90 = 3.3 time = 910
* CHECK dout0_4 vdout0_4ck90 = 3.3 time = 910
* CHECK dout0_5 vdout0_5ck90 = 0 time = 910
* CHECK dout0_6 vdout0_6ck90 = 3.3 time = 910
* CHECK dout0_7 vdout0_7ck90 = 0 time = 910
* CHECK dout0_8 vdout0_8ck90 = 0 time = 910
* CHECK dout0_9 vdout0_9ck90 = 0 time = 910
* CHECK dout0_10 vdout0_10ck90 = 0 time = 910
* CHECK dout0_11 vdout0_11ck90 = 3.3 time = 910
* CHECK dout0_12 vdout0_12ck90 = 0 time = 910
* CHECK dout0_13 vdout0_13ck90 = 3.3 time = 910
* CHECK dout0_14 vdout0_14ck90 = 0 time = 910
* CHECK dout0_15 vdout0_15ck90 = 0 time = 910
* CHECK dout0_16 vdout0_16ck90 = 3.3 time = 910
* CHECK dout0_17 vdout0_17ck90 = 0 time = 910
* CHECK dout0_18 vdout0_18ck90 = 3.3 time = 910
* CHECK dout0_19 vdout0_19ck90 = 0 time = 910
* CHECK dout0_20 vdout0_20ck90 = 3.3 time = 910
* CHECK dout0_21 vdout0_21ck90 = 3.3 time = 910
* CHECK dout0_22 vdout0_22ck90 = 3.3 time = 910
* CHECK dout0_23 vdout0_23ck90 = 0 time = 910
* CHECK dout0_24 vdout0_24ck90 = 0 time = 910
* CHECK dout0_25 vdout0_25ck90 = 0 time = 910
* CHECK dout0_26 vdout0_26ck90 = 0 time = 910
* CHECK dout0_27 vdout0_27ck90 = 3.3 time = 910
* CHECK dout0_28 vdout0_28ck90 = 0 time = 910
* CHECK dout0_29 vdout0_29ck90 = 0 time = 910
* CHECK dout0_30 vdout0_30ck90 = 0 time = 910
* CHECK dout0_31 vdout0_31ck90 = 3.3 time = 910
* CHECK dout0_32 vdout0_32ck90 = 0 time = 910
* CHECK dout0_0 vdout0_0ck91 = 0 time = 920
* CHECK dout0_1 vdout0_1ck91 = 3.3 time = 920
* CHECK dout0_2 vdout0_2ck91 = 0 time = 920
* CHECK dout0_3 vdout0_3ck91 = 0 time = 920
* CHECK dout0_4 vdout0_4ck91 = 3.3 time = 920
* CHECK dout0_5 vdout0_5ck91 = 0 time = 920
* CHECK dout0_6 vdout0_6ck91 = 3.3 time = 920
* CHECK dout0_7 vdout0_7ck91 = 3.3 time = 920
* CHECK dout0_8 vdout0_8ck91 = 0 time = 920
* CHECK dout0_9 vdout0_9ck91 = 3.3 time = 920
* CHECK dout0_10 vdout0_10ck91 = 3.3 time = 920
* CHECK dout0_11 vdout0_11ck91 = 3.3 time = 920
* CHECK dout0_12 vdout0_12ck91 = 3.3 time = 920
* CHECK dout0_13 vdout0_13ck91 = 0 time = 920
* CHECK dout0_14 vdout0_14ck91 = 3.3 time = 920
* CHECK dout0_15 vdout0_15ck91 = 3.3 time = 920
* CHECK dout0_16 vdout0_16ck91 = 3.3 time = 920
* CHECK dout0_17 vdout0_17ck91 = 3.3 time = 920
* CHECK dout0_18 vdout0_18ck91 = 3.3 time = 920
* CHECK dout0_19 vdout0_19ck91 = 0 time = 920
* CHECK dout0_20 vdout0_20ck91 = 3.3 time = 920
* CHECK dout0_21 vdout0_21ck91 = 0 time = 920
* CHECK dout0_22 vdout0_22ck91 = 3.3 time = 920
* CHECK dout0_23 vdout0_23ck91 = 0 time = 920
* CHECK dout0_24 vdout0_24ck91 = 3.3 time = 920
* CHECK dout0_25 vdout0_25ck91 = 3.3 time = 920
* CHECK dout0_26 vdout0_26ck91 = 0 time = 920
* CHECK dout0_27 vdout0_27ck91 = 0 time = 920
* CHECK dout0_28 vdout0_28ck91 = 0 time = 920
* CHECK dout0_29 vdout0_29ck91 = 3.3 time = 920
* CHECK dout0_30 vdout0_30ck91 = 0 time = 920
* CHECK dout0_31 vdout0_31ck91 = 0 time = 920
* CHECK dout0_32 vdout0_32ck91 = 0 time = 920
* CHECK dout0_0 vdout0_0ck92 = 3.3 time = 930
* CHECK dout0_1 vdout0_1ck92 = 3.3 time = 930
* CHECK dout0_2 vdout0_2ck92 = 0 time = 930
* CHECK dout0_3 vdout0_3ck92 = 3.3 time = 930
* CHECK dout0_4 vdout0_4ck92 = 3.3 time = 930
* CHECK dout0_5 vdout0_5ck92 = 0 time = 930
* CHECK dout0_6 vdout0_6ck92 = 3.3 time = 930
* CHECK dout0_7 vdout0_7ck92 = 0 time = 930
* CHECK dout0_8 vdout0_8ck92 = 0 time = 930
* CHECK dout0_9 vdout0_9ck92 = 0 time = 930
* CHECK dout0_10 vdout0_10ck92 = 0 time = 930
* CHECK dout0_11 vdout0_11ck92 = 3.3 time = 930
* CHECK dout0_12 vdout0_12ck92 = 0 time = 930
* CHECK dout0_13 vdout0_13ck92 = 3.3 time = 930
* CHECK dout0_14 vdout0_14ck92 = 0 time = 930
* CHECK dout0_15 vdout0_15ck92 = 0 time = 930
* CHECK dout0_16 vdout0_16ck92 = 3.3 time = 930
* CHECK dout0_17 vdout0_17ck92 = 0 time = 930
* CHECK dout0_18 vdout0_18ck92 = 3.3 time = 930
* CHECK dout0_19 vdout0_19ck92 = 0 time = 930
* CHECK dout0_20 vdout0_20ck92 = 3.3 time = 930
* CHECK dout0_21 vdout0_21ck92 = 3.3 time = 930
* CHECK dout0_22 vdout0_22ck92 = 3.3 time = 930
* CHECK dout0_23 vdout0_23ck92 = 0 time = 930
* CHECK dout0_24 vdout0_24ck92 = 0 time = 930
* CHECK dout0_25 vdout0_25ck92 = 0 time = 930
* CHECK dout0_26 vdout0_26ck92 = 0 time = 930
* CHECK dout0_27 vdout0_27ck92 = 3.3 time = 930
* CHECK dout0_28 vdout0_28ck92 = 0 time = 930
* CHECK dout0_29 vdout0_29ck92 = 0 time = 930
* CHECK dout0_30 vdout0_30ck92 = 0 time = 930
* CHECK dout0_31 vdout0_31ck92 = 3.3 time = 930
* CHECK dout0_32 vdout0_32ck92 = 0 time = 930
* CHECK dout0_0 vdout0_0ck93 = 0 time = 940
* CHECK dout0_1 vdout0_1ck93 = 3.3 time = 940
* CHECK dout0_2 vdout0_2ck93 = 0 time = 940
* CHECK dout0_3 vdout0_3ck93 = 0 time = 940
* CHECK dout0_4 vdout0_4ck93 = 3.3 time = 940
* CHECK dout0_5 vdout0_5ck93 = 0 time = 940
* CHECK dout0_6 vdout0_6ck93 = 3.3 time = 940
* CHECK dout0_7 vdout0_7ck93 = 3.3 time = 940
* CHECK dout0_8 vdout0_8ck93 = 0 time = 940
* CHECK dout0_9 vdout0_9ck93 = 3.3 time = 940
* CHECK dout0_10 vdout0_10ck93 = 3.3 time = 940
* CHECK dout0_11 vdout0_11ck93 = 3.3 time = 940
* CHECK dout0_12 vdout0_12ck93 = 3.3 time = 940
* CHECK dout0_13 vdout0_13ck93 = 0 time = 940
* CHECK dout0_14 vdout0_14ck93 = 3.3 time = 940
* CHECK dout0_15 vdout0_15ck93 = 3.3 time = 940
* CHECK dout0_16 vdout0_16ck93 = 3.3 time = 940
* CHECK dout0_17 vdout0_17ck93 = 3.3 time = 940
* CHECK dout0_18 vdout0_18ck93 = 3.3 time = 940
* CHECK dout0_19 vdout0_19ck93 = 0 time = 940
* CHECK dout0_20 vdout0_20ck93 = 3.3 time = 940
* CHECK dout0_21 vdout0_21ck93 = 0 time = 940
* CHECK dout0_22 vdout0_22ck93 = 3.3 time = 940
* CHECK dout0_23 vdout0_23ck93 = 0 time = 940
* CHECK dout0_24 vdout0_24ck93 = 3.3 time = 940
* CHECK dout0_25 vdout0_25ck93 = 3.3 time = 940
* CHECK dout0_26 vdout0_26ck93 = 0 time = 940
* CHECK dout0_27 vdout0_27ck93 = 0 time = 940
* CHECK dout0_28 vdout0_28ck93 = 0 time = 940
* CHECK dout0_29 vdout0_29ck93 = 3.3 time = 940
* CHECK dout0_30 vdout0_30ck93 = 0 time = 940
* CHECK dout0_31 vdout0_31ck93 = 0 time = 940
* CHECK dout0_32 vdout0_32ck93 = 0 time = 940
* CHECK dout0_0 vdout0_0ck94 = 3.3 time = 950
* CHECK dout0_1 vdout0_1ck94 = 3.3 time = 950
* CHECK dout0_2 vdout0_2ck94 = 0 time = 950
* CHECK dout0_3 vdout0_3ck94 = 3.3 time = 950
* CHECK dout0_4 vdout0_4ck94 = 3.3 time = 950
* CHECK dout0_5 vdout0_5ck94 = 0 time = 950
* CHECK dout0_6 vdout0_6ck94 = 3.3 time = 950
* CHECK dout0_7 vdout0_7ck94 = 0 time = 950
* CHECK dout0_8 vdout0_8ck94 = 0 time = 950
* CHECK dout0_9 vdout0_9ck94 = 0 time = 950
* CHECK dout0_10 vdout0_10ck94 = 0 time = 950
* CHECK dout0_11 vdout0_11ck94 = 3.3 time = 950
* CHECK dout0_12 vdout0_12ck94 = 0 time = 950
* CHECK dout0_13 vdout0_13ck94 = 3.3 time = 950
* CHECK dout0_14 vdout0_14ck94 = 0 time = 950
* CHECK dout0_15 vdout0_15ck94 = 0 time = 950
* CHECK dout0_16 vdout0_16ck94 = 3.3 time = 950
* CHECK dout0_17 vdout0_17ck94 = 0 time = 950
* CHECK dout0_18 vdout0_18ck94 = 3.3 time = 950
* CHECK dout0_19 vdout0_19ck94 = 0 time = 950
* CHECK dout0_20 vdout0_20ck94 = 3.3 time = 950
* CHECK dout0_21 vdout0_21ck94 = 3.3 time = 950
* CHECK dout0_22 vdout0_22ck94 = 3.3 time = 950
* CHECK dout0_23 vdout0_23ck94 = 0 time = 950
* CHECK dout0_24 vdout0_24ck94 = 0 time = 950
* CHECK dout0_25 vdout0_25ck94 = 0 time = 950
* CHECK dout0_26 vdout0_26ck94 = 0 time = 950
* CHECK dout0_27 vdout0_27ck94 = 3.3 time = 950
* CHECK dout0_28 vdout0_28ck94 = 0 time = 950
* CHECK dout0_29 vdout0_29ck94 = 0 time = 950
* CHECK dout0_30 vdout0_30ck94 = 0 time = 950
* CHECK dout0_31 vdout0_31ck94 = 3.3 time = 950
* CHECK dout0_32 vdout0_32ck94 = 0 time = 950
* CHECK dout0_0 vdout0_0ck96 = 3.3 time = 970
* CHECK dout0_1 vdout0_1ck96 = 3.3 time = 970
* CHECK dout0_2 vdout0_2ck96 = 0 time = 970
* CHECK dout0_3 vdout0_3ck96 = 3.3 time = 970
* CHECK dout0_4 vdout0_4ck96 = 3.3 time = 970
* CHECK dout0_5 vdout0_5ck96 = 0 time = 970
* CHECK dout0_6 vdout0_6ck96 = 3.3 time = 970
* CHECK dout0_7 vdout0_7ck96 = 0 time = 970
* CHECK dout0_8 vdout0_8ck96 = 0 time = 970
* CHECK dout0_9 vdout0_9ck96 = 0 time = 970
* CHECK dout0_10 vdout0_10ck96 = 0 time = 970
* CHECK dout0_11 vdout0_11ck96 = 3.3 time = 970
* CHECK dout0_12 vdout0_12ck96 = 0 time = 970
* CHECK dout0_13 vdout0_13ck96 = 3.3 time = 970
* CHECK dout0_14 vdout0_14ck96 = 0 time = 970
* CHECK dout0_15 vdout0_15ck96 = 0 time = 970
* CHECK dout0_16 vdout0_16ck96 = 3.3 time = 970
* CHECK dout0_17 vdout0_17ck96 = 0 time = 970
* CHECK dout0_18 vdout0_18ck96 = 3.3 time = 970
* CHECK dout0_19 vdout0_19ck96 = 0 time = 970
* CHECK dout0_20 vdout0_20ck96 = 3.3 time = 970
* CHECK dout0_21 vdout0_21ck96 = 3.3 time = 970
* CHECK dout0_22 vdout0_22ck96 = 3.3 time = 970
* CHECK dout0_23 vdout0_23ck96 = 0 time = 970
* CHECK dout0_24 vdout0_24ck96 = 0 time = 970
* CHECK dout0_25 vdout0_25ck96 = 0 time = 970
* CHECK dout0_26 vdout0_26ck96 = 0 time = 970
* CHECK dout0_27 vdout0_27ck96 = 3.3 time = 970
* CHECK dout0_28 vdout0_28ck96 = 0 time = 970
* CHECK dout0_29 vdout0_29ck96 = 0 time = 970
* CHECK dout0_30 vdout0_30ck96 = 0 time = 970
* CHECK dout0_31 vdout0_31ck96 = 3.3 time = 970
* CHECK dout0_32 vdout0_32ck96 = 0 time = 970
* CHECK dout0_0 vdout0_0ck97 = 3.3 time = 980
* CHECK dout0_1 vdout0_1ck97 = 0 time = 980
* CHECK dout0_2 vdout0_2ck97 = 0 time = 980
* CHECK dout0_3 vdout0_3ck97 = 3.3 time = 980
* CHECK dout0_4 vdout0_4ck97 = 3.3 time = 980
* CHECK dout0_5 vdout0_5ck97 = 3.3 time = 980
* CHECK dout0_6 vdout0_6ck97 = 0 time = 980
* CHECK dout0_7 vdout0_7ck97 = 3.3 time = 980
* CHECK dout0_8 vdout0_8ck97 = 3.3 time = 980
* CHECK dout0_9 vdout0_9ck97 = 0 time = 980
* CHECK dout0_10 vdout0_10ck97 = 3.3 time = 980
* CHECK dout0_11 vdout0_11ck97 = 0 time = 980
* CHECK dout0_12 vdout0_12ck97 = 3.3 time = 980
* CHECK dout0_13 vdout0_13ck97 = 3.3 time = 980
* CHECK dout0_14 vdout0_14ck97 = 0 time = 980
* CHECK dout0_15 vdout0_15ck97 = 0 time = 980
* CHECK dout0_16 vdout0_16ck97 = 3.3 time = 980
* CHECK dout0_17 vdout0_17ck97 = 3.3 time = 980
* CHECK dout0_18 vdout0_18ck97 = 3.3 time = 980
* CHECK dout0_19 vdout0_19ck97 = 3.3 time = 980
* CHECK dout0_20 vdout0_20ck97 = 0 time = 980
* CHECK dout0_21 vdout0_21ck97 = 0 time = 980
* CHECK dout0_22 vdout0_22ck97 = 3.3 time = 980
* CHECK dout0_23 vdout0_23ck97 = 3.3 time = 980
* CHECK dout0_24 vdout0_24ck97 = 3.3 time = 980
* CHECK dout0_25 vdout0_25ck97 = 0 time = 980
* CHECK dout0_26 vdout0_26ck97 = 0 time = 980
* CHECK dout0_27 vdout0_27ck97 = 0 time = 980
* CHECK dout0_28 vdout0_28ck97 = 0 time = 980
* CHECK dout0_29 vdout0_29ck97 = 3.3 time = 980
* CHECK dout0_30 vdout0_30ck97 = 3.3 time = 980
* CHECK dout0_31 vdout0_31ck97 = 3.3 time = 980
* CHECK dout0_32 vdout0_32ck97 = 0 time = 980
* CHECK dout0_0 vdout0_0ck98 = 3.3 time = 990
* CHECK dout0_1 vdout0_1ck98 = 0 time = 990
* CHECK dout0_2 vdout0_2ck98 = 0 time = 990
* CHECK dout0_3 vdout0_3ck98 = 3.3 time = 990
* CHECK dout0_4 vdout0_4ck98 = 3.3 time = 990
* CHECK dout0_5 vdout0_5ck98 = 3.3 time = 990
* CHECK dout0_6 vdout0_6ck98 = 0 time = 990
* CHECK dout0_7 vdout0_7ck98 = 3.3 time = 990
* CHECK dout0_8 vdout0_8ck98 = 3.3 time = 990
* CHECK dout0_9 vdout0_9ck98 = 0 time = 990
* CHECK dout0_10 vdout0_10ck98 = 3.3 time = 990
* CHECK dout0_11 vdout0_11ck98 = 0 time = 990
* CHECK dout0_12 vdout0_12ck98 = 3.3 time = 990
* CHECK dout0_13 vdout0_13ck98 = 3.3 time = 990
* CHECK dout0_14 vdout0_14ck98 = 0 time = 990
* CHECK dout0_15 vdout0_15ck98 = 0 time = 990
* CHECK dout0_16 vdout0_16ck98 = 3.3 time = 990
* CHECK dout0_17 vdout0_17ck98 = 3.3 time = 990
* CHECK dout0_18 vdout0_18ck98 = 3.3 time = 990
* CHECK dout0_19 vdout0_19ck98 = 3.3 time = 990
* CHECK dout0_20 vdout0_20ck98 = 0 time = 990
* CHECK dout0_21 vdout0_21ck98 = 0 time = 990
* CHECK dout0_22 vdout0_22ck98 = 3.3 time = 990
* CHECK dout0_23 vdout0_23ck98 = 3.3 time = 990
* CHECK dout0_24 vdout0_24ck98 = 3.3 time = 990
* CHECK dout0_25 vdout0_25ck98 = 0 time = 990
* CHECK dout0_26 vdout0_26ck98 = 0 time = 990
* CHECK dout0_27 vdout0_27ck98 = 0 time = 990
* CHECK dout0_28 vdout0_28ck98 = 0 time = 990
* CHECK dout0_29 vdout0_29ck98 = 3.3 time = 990
* CHECK dout0_30 vdout0_30ck98 = 3.3 time = 990
* CHECK dout0_31 vdout0_31ck98 = 3.3 time = 990
* CHECK dout0_32 vdout0_32ck98 = 0 time = 990
* CHECK dout0_0 vdout0_0ck99 = 3.3 time = 1000
* CHECK dout0_1 vdout0_1ck99 = 3.3 time = 1000
* CHECK dout0_2 vdout0_2ck99 = 0 time = 1000
* CHECK dout0_3 vdout0_3ck99 = 3.3 time = 1000
* CHECK dout0_4 vdout0_4ck99 = 3.3 time = 1000
* CHECK dout0_5 vdout0_5ck99 = 0 time = 1000
* CHECK dout0_6 vdout0_6ck99 = 3.3 time = 1000
* CHECK dout0_7 vdout0_7ck99 = 0 time = 1000
* CHECK dout0_8 vdout0_8ck99 = 0 time = 1000
* CHECK dout0_9 vdout0_9ck99 = 0 time = 1000
* CHECK dout0_10 vdout0_10ck99 = 0 time = 1000
* CHECK dout0_11 vdout0_11ck99 = 3.3 time = 1000
* CHECK dout0_12 vdout0_12ck99 = 0 time = 1000
* CHECK dout0_13 vdout0_13ck99 = 3.3 time = 1000
* CHECK dout0_14 vdout0_14ck99 = 0 time = 1000
* CHECK dout0_15 vdout0_15ck99 = 0 time = 1000
* CHECK dout0_16 vdout0_16ck99 = 3.3 time = 1000
* CHECK dout0_17 vdout0_17ck99 = 0 time = 1000
* CHECK dout0_18 vdout0_18ck99 = 3.3 time = 1000
* CHECK dout0_19 vdout0_19ck99 = 0 time = 1000
* CHECK dout0_20 vdout0_20ck99 = 3.3 time = 1000
* CHECK dout0_21 vdout0_21ck99 = 3.3 time = 1000
* CHECK dout0_22 vdout0_22ck99 = 3.3 time = 1000
* CHECK dout0_23 vdout0_23ck99 = 0 time = 1000
* CHECK dout0_24 vdout0_24ck99 = 0 time = 1000
* CHECK dout0_25 vdout0_25ck99 = 0 time = 1000
* CHECK dout0_26 vdout0_26ck99 = 0 time = 1000
* CHECK dout0_27 vdout0_27ck99 = 3.3 time = 1000
* CHECK dout0_28 vdout0_28ck99 = 0 time = 1000
* CHECK dout0_29 vdout0_29ck99 = 0 time = 1000
* CHECK dout0_30 vdout0_30ck99 = 0 time = 1000
* CHECK dout0_31 vdout0_31ck99 = 3.3 time = 1000
* CHECK dout0_32 vdout0_32ck99 = 0 time = 1000
* CHECK dout0_0 vdout0_0ck100 = 3.3 time = 1010
* CHECK dout0_1 vdout0_1ck100 = 0 time = 1010
* CHECK dout0_2 vdout0_2ck100 = 0 time = 1010
* CHECK dout0_3 vdout0_3ck100 = 3.3 time = 1010
* CHECK dout0_4 vdout0_4ck100 = 3.3 time = 1010
* CHECK dout0_5 vdout0_5ck100 = 3.3 time = 1010
* CHECK dout0_6 vdout0_6ck100 = 0 time = 1010
* CHECK dout0_7 vdout0_7ck100 = 3.3 time = 1010
* CHECK dout0_8 vdout0_8ck100 = 3.3 time = 1010
* CHECK dout0_9 vdout0_9ck100 = 0 time = 1010
* CHECK dout0_10 vdout0_10ck100 = 3.3 time = 1010
* CHECK dout0_11 vdout0_11ck100 = 0 time = 1010
* CHECK dout0_12 vdout0_12ck100 = 3.3 time = 1010
* CHECK dout0_13 vdout0_13ck100 = 3.3 time = 1010
* CHECK dout0_14 vdout0_14ck100 = 0 time = 1010
* CHECK dout0_15 vdout0_15ck100 = 0 time = 1010
* CHECK dout0_16 vdout0_16ck100 = 3.3 time = 1010
* CHECK dout0_17 vdout0_17ck100 = 3.3 time = 1010
* CHECK dout0_18 vdout0_18ck100 = 3.3 time = 1010
* CHECK dout0_19 vdout0_19ck100 = 3.3 time = 1010
* CHECK dout0_20 vdout0_20ck100 = 0 time = 1010
* CHECK dout0_21 vdout0_21ck100 = 0 time = 1010
* CHECK dout0_22 vdout0_22ck100 = 3.3 time = 1010
* CHECK dout0_23 vdout0_23ck100 = 3.3 time = 1010
* CHECK dout0_24 vdout0_24ck100 = 3.3 time = 1010
* CHECK dout0_25 vdout0_25ck100 = 0 time = 1010
* CHECK dout0_26 vdout0_26ck100 = 0 time = 1010
* CHECK dout0_27 vdout0_27ck100 = 0 time = 1010
* CHECK dout0_28 vdout0_28ck100 = 0 time = 1010
* CHECK dout0_29 vdout0_29ck100 = 3.3 time = 1010
* CHECK dout0_30 vdout0_30ck100 = 3.3 time = 1010
* CHECK dout0_31 vdout0_31ck100 = 3.3 time = 1010
* CHECK dout0_32 vdout0_32ck100 = 0 time = 1010
* CHECK dout0_0 vdout0_0ck101 = 3.3 time = 1020
* CHECK dout0_1 vdout0_1ck101 = 0 time = 1020
* CHECK dout0_2 vdout0_2ck101 = 0 time = 1020
* CHECK dout0_3 vdout0_3ck101 = 3.3 time = 1020
* CHECK dout0_4 vdout0_4ck101 = 3.3 time = 1020
* CHECK dout0_5 vdout0_5ck101 = 3.3 time = 1020
* CHECK dout0_6 vdout0_6ck101 = 0 time = 1020
* CHECK dout0_7 vdout0_7ck101 = 3.3 time = 1020
* CHECK dout0_8 vdout0_8ck101 = 3.3 time = 1020
* CHECK dout0_9 vdout0_9ck101 = 0 time = 1020
* CHECK dout0_10 vdout0_10ck101 = 3.3 time = 1020
* CHECK dout0_11 vdout0_11ck101 = 0 time = 1020
* CHECK dout0_12 vdout0_12ck101 = 3.3 time = 1020
* CHECK dout0_13 vdout0_13ck101 = 3.3 time = 1020
* CHECK dout0_14 vdout0_14ck101 = 0 time = 1020
* CHECK dout0_15 vdout0_15ck101 = 0 time = 1020
* CHECK dout0_16 vdout0_16ck101 = 3.3 time = 1020
* CHECK dout0_17 vdout0_17ck101 = 3.3 time = 1020
* CHECK dout0_18 vdout0_18ck101 = 3.3 time = 1020
* CHECK dout0_19 vdout0_19ck101 = 3.3 time = 1020
* CHECK dout0_20 vdout0_20ck101 = 0 time = 1020
* CHECK dout0_21 vdout0_21ck101 = 0 time = 1020
* CHECK dout0_22 vdout0_22ck101 = 3.3 time = 1020
* CHECK dout0_23 vdout0_23ck101 = 3.3 time = 1020
* CHECK dout0_24 vdout0_24ck101 = 3.3 time = 1020
* CHECK dout0_25 vdout0_25ck101 = 0 time = 1020
* CHECK dout0_26 vdout0_26ck101 = 0 time = 1020
* CHECK dout0_27 vdout0_27ck101 = 0 time = 1020
* CHECK dout0_28 vdout0_28ck101 = 0 time = 1020
* CHECK dout0_29 vdout0_29ck101 = 3.3 time = 1020
* CHECK dout0_30 vdout0_30ck101 = 3.3 time = 1020
* CHECK dout0_31 vdout0_31ck101 = 3.3 time = 1020
* CHECK dout0_32 vdout0_32ck101 = 0 time = 1020
* CHECK dout0_0 vdout0_0ck102 = 3.3 time = 1030
* CHECK dout0_1 vdout0_1ck102 = 3.3 time = 1030
* CHECK dout0_2 vdout0_2ck102 = 0 time = 1030
* CHECK dout0_3 vdout0_3ck102 = 3.3 time = 1030
* CHECK dout0_4 vdout0_4ck102 = 3.3 time = 1030
* CHECK dout0_5 vdout0_5ck102 = 0 time = 1030
* CHECK dout0_6 vdout0_6ck102 = 3.3 time = 1030
* CHECK dout0_7 vdout0_7ck102 = 0 time = 1030
* CHECK dout0_8 vdout0_8ck102 = 0 time = 1030
* CHECK dout0_9 vdout0_9ck102 = 0 time = 1030
* CHECK dout0_10 vdout0_10ck102 = 0 time = 1030
* CHECK dout0_11 vdout0_11ck102 = 3.3 time = 1030
* CHECK dout0_12 vdout0_12ck102 = 0 time = 1030
* CHECK dout0_13 vdout0_13ck102 = 3.3 time = 1030
* CHECK dout0_14 vdout0_14ck102 = 0 time = 1030
* CHECK dout0_15 vdout0_15ck102 = 0 time = 1030
* CHECK dout0_16 vdout0_16ck102 = 3.3 time = 1030
* CHECK dout0_17 vdout0_17ck102 = 0 time = 1030
* CHECK dout0_18 vdout0_18ck102 = 3.3 time = 1030
* CHECK dout0_19 vdout0_19ck102 = 0 time = 1030
* CHECK dout0_20 vdout0_20ck102 = 3.3 time = 1030
* CHECK dout0_21 vdout0_21ck102 = 3.3 time = 1030
* CHECK dout0_22 vdout0_22ck102 = 3.3 time = 1030
* CHECK dout0_23 vdout0_23ck102 = 0 time = 1030
* CHECK dout0_24 vdout0_24ck102 = 0 time = 1030
* CHECK dout0_25 vdout0_25ck102 = 0 time = 1030
* CHECK dout0_26 vdout0_26ck102 = 0 time = 1030
* CHECK dout0_27 vdout0_27ck102 = 3.3 time = 1030
* CHECK dout0_28 vdout0_28ck102 = 0 time = 1030
* CHECK dout0_29 vdout0_29ck102 = 0 time = 1030
* CHECK dout0_30 vdout0_30ck102 = 0 time = 1030
* CHECK dout0_31 vdout0_31ck102 = 3.3 time = 1030
* CHECK dout0_32 vdout0_32ck102 = 0 time = 1030
* CHECK dout0_0 vdout0_0ck103 = 3.3 time = 1040
* CHECK dout0_1 vdout0_1ck103 = 0 time = 1040
* CHECK dout0_2 vdout0_2ck103 = 0 time = 1040
* CHECK dout0_3 vdout0_3ck103 = 3.3 time = 1040
* CHECK dout0_4 vdout0_4ck103 = 3.3 time = 1040
* CHECK dout0_5 vdout0_5ck103 = 3.3 time = 1040
* CHECK dout0_6 vdout0_6ck103 = 0 time = 1040
* CHECK dout0_7 vdout0_7ck103 = 3.3 time = 1040
* CHECK dout0_8 vdout0_8ck103 = 3.3 time = 1040
* CHECK dout0_9 vdout0_9ck103 = 0 time = 1040
* CHECK dout0_10 vdout0_10ck103 = 3.3 time = 1040
* CHECK dout0_11 vdout0_11ck103 = 0 time = 1040
* CHECK dout0_12 vdout0_12ck103 = 3.3 time = 1040
* CHECK dout0_13 vdout0_13ck103 = 3.3 time = 1040
* CHECK dout0_14 vdout0_14ck103 = 0 time = 1040
* CHECK dout0_15 vdout0_15ck103 = 0 time = 1040
* CHECK dout0_16 vdout0_16ck103 = 3.3 time = 1040
* CHECK dout0_17 vdout0_17ck103 = 3.3 time = 1040
* CHECK dout0_18 vdout0_18ck103 = 3.3 time = 1040
* CHECK dout0_19 vdout0_19ck103 = 3.3 time = 1040
* CHECK dout0_20 vdout0_20ck103 = 0 time = 1040
* CHECK dout0_21 vdout0_21ck103 = 0 time = 1040
* CHECK dout0_22 vdout0_22ck103 = 3.3 time = 1040
* CHECK dout0_23 vdout0_23ck103 = 3.3 time = 1040
* CHECK dout0_24 vdout0_24ck103 = 3.3 time = 1040
* CHECK dout0_25 vdout0_25ck103 = 0 time = 1040
* CHECK dout0_26 vdout0_26ck103 = 0 time = 1040
* CHECK dout0_27 vdout0_27ck103 = 0 time = 1040
* CHECK dout0_28 vdout0_28ck103 = 0 time = 1040
* CHECK dout0_29 vdout0_29ck103 = 3.3 time = 1040
* CHECK dout0_30 vdout0_30ck103 = 3.3 time = 1040
* CHECK dout0_31 vdout0_31ck103 = 3.3 time = 1040
* CHECK dout0_32 vdout0_32ck103 = 0 time = 1040
* CHECK dout0_0 vdout0_0ck104 = 3.3 time = 1050
* CHECK dout0_1 vdout0_1ck104 = 3.3 time = 1050
* CHECK dout0_2 vdout0_2ck104 = 0 time = 1050
* CHECK dout0_3 vdout0_3ck104 = 3.3 time = 1050
* CHECK dout0_4 vdout0_4ck104 = 3.3 time = 1050
* CHECK dout0_5 vdout0_5ck104 = 0 time = 1050
* CHECK dout0_6 vdout0_6ck104 = 3.3 time = 1050
* CHECK dout0_7 vdout0_7ck104 = 0 time = 1050
* CHECK dout0_8 vdout0_8ck104 = 0 time = 1050
* CHECK dout0_9 vdout0_9ck104 = 0 time = 1050
* CHECK dout0_10 vdout0_10ck104 = 0 time = 1050
* CHECK dout0_11 vdout0_11ck104 = 3.3 time = 1050
* CHECK dout0_12 vdout0_12ck104 = 0 time = 1050
* CHECK dout0_13 vdout0_13ck104 = 3.3 time = 1050
* CHECK dout0_14 vdout0_14ck104 = 0 time = 1050
* CHECK dout0_15 vdout0_15ck104 = 0 time = 1050
* CHECK dout0_16 vdout0_16ck104 = 3.3 time = 1050
* CHECK dout0_17 vdout0_17ck104 = 0 time = 1050
* CHECK dout0_18 vdout0_18ck104 = 3.3 time = 1050
* CHECK dout0_19 vdout0_19ck104 = 0 time = 1050
* CHECK dout0_20 vdout0_20ck104 = 3.3 time = 1050
* CHECK dout0_21 vdout0_21ck104 = 3.3 time = 1050
* CHECK dout0_22 vdout0_22ck104 = 3.3 time = 1050
* CHECK dout0_23 vdout0_23ck104 = 0 time = 1050
* CHECK dout0_24 vdout0_24ck104 = 0 time = 1050
* CHECK dout0_25 vdout0_25ck104 = 0 time = 1050
* CHECK dout0_26 vdout0_26ck104 = 0 time = 1050
* CHECK dout0_27 vdout0_27ck104 = 3.3 time = 1050
* CHECK dout0_28 vdout0_28ck104 = 0 time = 1050
* CHECK dout0_29 vdout0_29ck104 = 0 time = 1050
* CHECK dout0_30 vdout0_30ck104 = 0 time = 1050
* CHECK dout0_31 vdout0_31ck104 = 3.3 time = 1050
* CHECK dout0_32 vdout0_32ck104 = 0 time = 1050
* CHECK dout0_0 vdout0_0ck106 = 3.3 time = 1070
* CHECK dout0_1 vdout0_1ck106 = 0 time = 1070
* CHECK dout0_2 vdout0_2ck106 = 0 time = 1070
* CHECK dout0_3 vdout0_3ck106 = 3.3 time = 1070
* CHECK dout0_4 vdout0_4ck106 = 3.3 time = 1070
* CHECK dout0_5 vdout0_5ck106 = 3.3 time = 1070
* CHECK dout0_6 vdout0_6ck106 = 0 time = 1070
* CHECK dout0_7 vdout0_7ck106 = 3.3 time = 1070
* CHECK dout0_8 vdout0_8ck106 = 3.3 time = 1070
* CHECK dout0_9 vdout0_9ck106 = 0 time = 1070
* CHECK dout0_10 vdout0_10ck106 = 3.3 time = 1070
* CHECK dout0_11 vdout0_11ck106 = 0 time = 1070
* CHECK dout0_12 vdout0_12ck106 = 3.3 time = 1070
* CHECK dout0_13 vdout0_13ck106 = 3.3 time = 1070
* CHECK dout0_14 vdout0_14ck106 = 0 time = 1070
* CHECK dout0_15 vdout0_15ck106 = 0 time = 1070
* CHECK dout0_16 vdout0_16ck106 = 3.3 time = 1070
* CHECK dout0_17 vdout0_17ck106 = 3.3 time = 1070
* CHECK dout0_18 vdout0_18ck106 = 3.3 time = 1070
* CHECK dout0_19 vdout0_19ck106 = 3.3 time = 1070
* CHECK dout0_20 vdout0_20ck106 = 0 time = 1070
* CHECK dout0_21 vdout0_21ck106 = 0 time = 1070
* CHECK dout0_22 vdout0_22ck106 = 3.3 time = 1070
* CHECK dout0_23 vdout0_23ck106 = 3.3 time = 1070
* CHECK dout0_24 vdout0_24ck106 = 3.3 time = 1070
* CHECK dout0_25 vdout0_25ck106 = 0 time = 1070
* CHECK dout0_26 vdout0_26ck106 = 0 time = 1070
* CHECK dout0_27 vdout0_27ck106 = 0 time = 1070
* CHECK dout0_28 vdout0_28ck106 = 0 time = 1070
* CHECK dout0_29 vdout0_29ck106 = 3.3 time = 1070
* CHECK dout0_30 vdout0_30ck106 = 3.3 time = 1070
* CHECK dout0_31 vdout0_31ck106 = 3.3 time = 1070
* CHECK dout0_32 vdout0_32ck106 = 0 time = 1070
* CHECK dout0_0 vdout0_0ck108 = 3.3 time = 1090
* CHECK dout0_1 vdout0_1ck108 = 3.3 time = 1090
* CHECK dout0_2 vdout0_2ck108 = 0 time = 1090
* CHECK dout0_3 vdout0_3ck108 = 3.3 time = 1090
* CHECK dout0_4 vdout0_4ck108 = 3.3 time = 1090
* CHECK dout0_5 vdout0_5ck108 = 0 time = 1090
* CHECK dout0_6 vdout0_6ck108 = 3.3 time = 1090
* CHECK dout0_7 vdout0_7ck108 = 0 time = 1090
* CHECK dout0_8 vdout0_8ck108 = 0 time = 1090
* CHECK dout0_9 vdout0_9ck108 = 0 time = 1090
* CHECK dout0_10 vdout0_10ck108 = 0 time = 1090
* CHECK dout0_11 vdout0_11ck108 = 3.3 time = 1090
* CHECK dout0_12 vdout0_12ck108 = 0 time = 1090
* CHECK dout0_13 vdout0_13ck108 = 3.3 time = 1090
* CHECK dout0_14 vdout0_14ck108 = 0 time = 1090
* CHECK dout0_15 vdout0_15ck108 = 0 time = 1090
* CHECK dout0_16 vdout0_16ck108 = 3.3 time = 1090
* CHECK dout0_17 vdout0_17ck108 = 0 time = 1090
* CHECK dout0_18 vdout0_18ck108 = 3.3 time = 1090
* CHECK dout0_19 vdout0_19ck108 = 0 time = 1090
* CHECK dout0_20 vdout0_20ck108 = 3.3 time = 1090
* CHECK dout0_21 vdout0_21ck108 = 3.3 time = 1090
* CHECK dout0_22 vdout0_22ck108 = 3.3 time = 1090
* CHECK dout0_23 vdout0_23ck108 = 0 time = 1090
* CHECK dout0_24 vdout0_24ck108 = 0 time = 1090
* CHECK dout0_25 vdout0_25ck108 = 0 time = 1090
* CHECK dout0_26 vdout0_26ck108 = 0 time = 1090
* CHECK dout0_27 vdout0_27ck108 = 3.3 time = 1090
* CHECK dout0_28 vdout0_28ck108 = 0 time = 1090
* CHECK dout0_29 vdout0_29ck108 = 0 time = 1090
* CHECK dout0_30 vdout0_30ck108 = 0 time = 1090
* CHECK dout0_31 vdout0_31ck108 = 3.3 time = 1090
* CHECK dout0_32 vdout0_32ck108 = 0 time = 1090
* CHECK dout0_0 vdout0_0ck111 = 3.3 time = 1120
* CHECK dout0_1 vdout0_1ck111 = 0 time = 1120
* CHECK dout0_2 vdout0_2ck111 = 0 time = 1120
* CHECK dout0_3 vdout0_3ck111 = 0 time = 1120
* CHECK dout0_4 vdout0_4ck111 = 0 time = 1120
* CHECK dout0_5 vdout0_5ck111 = 0 time = 1120
* CHECK dout0_6 vdout0_6ck111 = 0 time = 1120
* CHECK dout0_7 vdout0_7ck111 = 0 time = 1120
* CHECK dout0_8 vdout0_8ck111 = 3.3 time = 1120
* CHECK dout0_9 vdout0_9ck111 = 3.3 time = 1120
* CHECK dout0_10 vdout0_10ck111 = 0 time = 1120
* CHECK dout0_11 vdout0_11ck111 = 3.3 time = 1120
* CHECK dout0_12 vdout0_12ck111 = 3.3 time = 1120
* CHECK dout0_13 vdout0_13ck111 = 0 time = 1120
* CHECK dout0_14 vdout0_14ck111 = 0 time = 1120
* CHECK dout0_15 vdout0_15ck111 = 0 time = 1120
* CHECK dout0_16 vdout0_16ck111 = 0 time = 1120
* CHECK dout0_17 vdout0_17ck111 = 0 time = 1120
* CHECK dout0_18 vdout0_18ck111 = 3.3 time = 1120
* CHECK dout0_19 vdout0_19ck111 = 3.3 time = 1120
* CHECK dout0_20 vdout0_20ck111 = 0 time = 1120
* CHECK dout0_21 vdout0_21ck111 = 3.3 time = 1120
* CHECK dout0_22 vdout0_22ck111 = 0 time = 1120
* CHECK dout0_23 vdout0_23ck111 = 0 time = 1120
* CHECK dout0_24 vdout0_24ck111 = 3.3 time = 1120
* CHECK dout0_25 vdout0_25ck111 = 3.3 time = 1120
* CHECK dout0_26 vdout0_26ck111 = 3.3 time = 1120
* CHECK dout0_27 vdout0_27ck111 = 3.3 time = 1120
* CHECK dout0_28 vdout0_28ck111 = 0 time = 1120
* CHECK dout0_29 vdout0_29ck111 = 3.3 time = 1120
* CHECK dout0_30 vdout0_30ck111 = 0 time = 1120
* CHECK dout0_31 vdout0_31ck111 = 0 time = 1120
* CHECK dout0_32 vdout0_32ck111 = 0 time = 1120
* CHECK dout0_0 vdout0_0ck114 = 0 time = 1150
* CHECK dout0_1 vdout0_1ck114 = 0 time = 1150
* CHECK dout0_2 vdout0_2ck114 = 0 time = 1150
* CHECK dout0_3 vdout0_3ck114 = 0 time = 1150
* CHECK dout0_4 vdout0_4ck114 = 0 time = 1150
* CHECK dout0_5 vdout0_5ck114 = 0 time = 1150
* CHECK dout0_6 vdout0_6ck114 = 0 time = 1150
* CHECK dout0_7 vdout0_7ck114 = 0 time = 1150
* CHECK dout0_8 vdout0_8ck114 = 0 time = 1150
* CHECK dout0_9 vdout0_9ck114 = 0 time = 1150
* CHECK dout0_10 vdout0_10ck114 = 3.3 time = 1150
* CHECK dout0_11 vdout0_11ck114 = 3.3 time = 1150
* CHECK dout0_12 vdout0_12ck114 = 0 time = 1150
* CHECK dout0_13 vdout0_13ck114 = 3.3 time = 1150
* CHECK dout0_14 vdout0_14ck114 = 3.3 time = 1150
* CHECK dout0_15 vdout0_15ck114 = 3.3 time = 1150
* CHECK dout0_16 vdout0_16ck114 = 0 time = 1150
* CHECK dout0_17 vdout0_17ck114 = 0 time = 1150
* CHECK dout0_18 vdout0_18ck114 = 0 time = 1150
* CHECK dout0_19 vdout0_19ck114 = 0 time = 1150
* CHECK dout0_20 vdout0_20ck114 = 3.3 time = 1150
* CHECK dout0_21 vdout0_21ck114 = 3.3 time = 1150
* CHECK dout0_22 vdout0_22ck114 = 3.3 time = 1150
* CHECK dout0_23 vdout0_23ck114 = 3.3 time = 1150
* CHECK dout0_24 vdout0_24ck114 = 3.3 time = 1150
* CHECK dout0_25 vdout0_25ck114 = 0 time = 1150
* CHECK dout0_26 vdout0_26ck114 = 0 time = 1150
* CHECK dout0_27 vdout0_27ck114 = 3.3 time = 1150
* CHECK dout0_28 vdout0_28ck114 = 3.3 time = 1150
* CHECK dout0_29 vdout0_29ck114 = 0 time = 1150
* CHECK dout0_30 vdout0_30ck114 = 0 time = 1150
* CHECK dout0_31 vdout0_31ck114 = 3.3 time = 1150
* CHECK dout0_32 vdout0_32ck114 = 0 time = 1150
* CHECK dout0_0 vdout0_0ck119 = 0 time = 1200
* CHECK dout0_1 vdout0_1ck119 = 0 time = 1200
* CHECK dout0_2 vdout0_2ck119 = 3.3 time = 1200
* CHECK dout0_3 vdout0_3ck119 = 0 time = 1200
* CHECK dout0_4 vdout0_4ck119 = 0 time = 1200
* CHECK dout0_5 vdout0_5ck119 = 0 time = 1200
* CHECK dout0_6 vdout0_6ck119 = 3.3 time = 1200
* CHECK dout0_7 vdout0_7ck119 = 3.3 time = 1200
* CHECK dout0_8 vdout0_8ck119 = 0 time = 1200
* CHECK dout0_9 vdout0_9ck119 = 3.3 time = 1200
* CHECK dout0_10 vdout0_10ck119 = 3.3 time = 1200
* CHECK dout0_11 vdout0_11ck119 = 0 time = 1200
* CHECK dout0_12 vdout0_12ck119 = 0 time = 1200
* CHECK dout0_13 vdout0_13ck119 = 3.3 time = 1200
* CHECK dout0_14 vdout0_14ck119 = 3.3 time = 1200
* CHECK dout0_15 vdout0_15ck119 = 0 time = 1200
* CHECK dout0_16 vdout0_16ck119 = 0 time = 1200
* CHECK dout0_17 vdout0_17ck119 = 3.3 time = 1200
* CHECK dout0_18 vdout0_18ck119 = 3.3 time = 1200
* CHECK dout0_19 vdout0_19ck119 = 0 time = 1200
* CHECK dout0_20 vdout0_20ck119 = 3.3 time = 1200
* CHECK dout0_21 vdout0_21ck119 = 0 time = 1200
* CHECK dout0_22 vdout0_22ck119 = 3.3 time = 1200
* CHECK dout0_23 vdout0_23ck119 = 3.3 time = 1200
* CHECK dout0_24 vdout0_24ck119 = 0 time = 1200
* CHECK dout0_25 vdout0_25ck119 = 0 time = 1200
* CHECK dout0_26 vdout0_26ck119 = 3.3 time = 1200
* CHECK dout0_27 vdout0_27ck119 = 3.3 time = 1200
* CHECK dout0_28 vdout0_28ck119 = 3.3 time = 1200
* CHECK dout0_29 vdout0_29ck119 = 0 time = 1200
* CHECK dout0_30 vdout0_30ck119 = 0 time = 1200
* CHECK dout0_31 vdout0_31ck119 = 0 time = 1200
* CHECK dout0_32 vdout0_32ck119 = 0 time = 1200
* CHECK dout0_0 vdout0_0ck120 = 0 time = 1210
* CHECK dout0_1 vdout0_1ck120 = 0 time = 1210
* CHECK dout0_2 vdout0_2ck120 = 3.3 time = 1210
* CHECK dout0_3 vdout0_3ck120 = 0 time = 1210
* CHECK dout0_4 vdout0_4ck120 = 0 time = 1210
* CHECK dout0_5 vdout0_5ck120 = 0 time = 1210
* CHECK dout0_6 vdout0_6ck120 = 3.3 time = 1210
* CHECK dout0_7 vdout0_7ck120 = 3.3 time = 1210
* CHECK dout0_8 vdout0_8ck120 = 0 time = 1210
* CHECK dout0_9 vdout0_9ck120 = 3.3 time = 1210
* CHECK dout0_10 vdout0_10ck120 = 3.3 time = 1210
* CHECK dout0_11 vdout0_11ck120 = 0 time = 1210
* CHECK dout0_12 vdout0_12ck120 = 0 time = 1210
* CHECK dout0_13 vdout0_13ck120 = 3.3 time = 1210
* CHECK dout0_14 vdout0_14ck120 = 3.3 time = 1210
* CHECK dout0_15 vdout0_15ck120 = 0 time = 1210
* CHECK dout0_16 vdout0_16ck120 = 0 time = 1210
* CHECK dout0_17 vdout0_17ck120 = 3.3 time = 1210
* CHECK dout0_18 vdout0_18ck120 = 3.3 time = 1210
* CHECK dout0_19 vdout0_19ck120 = 0 time = 1210
* CHECK dout0_20 vdout0_20ck120 = 3.3 time = 1210
* CHECK dout0_21 vdout0_21ck120 = 0 time = 1210
* CHECK dout0_22 vdout0_22ck120 = 3.3 time = 1210
* CHECK dout0_23 vdout0_23ck120 = 3.3 time = 1210
* CHECK dout0_24 vdout0_24ck120 = 0 time = 1210
* CHECK dout0_25 vdout0_25ck120 = 0 time = 1210
* CHECK dout0_26 vdout0_26ck120 = 3.3 time = 1210
* CHECK dout0_27 vdout0_27ck120 = 3.3 time = 1210
* CHECK dout0_28 vdout0_28ck120 = 3.3 time = 1210
* CHECK dout0_29 vdout0_29ck120 = 0 time = 1210
* CHECK dout0_30 vdout0_30ck120 = 0 time = 1210
* CHECK dout0_31 vdout0_31ck120 = 0 time = 1210
* CHECK dout0_32 vdout0_32ck120 = 0 time = 1210
* CHECK dout0_0 vdout0_0ck122 = 3.3 time = 1230
* CHECK dout0_1 vdout0_1ck122 = 0 time = 1230
* CHECK dout0_2 vdout0_2ck122 = 3.3 time = 1230
* CHECK dout0_3 vdout0_3ck122 = 0 time = 1230
* CHECK dout0_4 vdout0_4ck122 = 0 time = 1230
* CHECK dout0_5 vdout0_5ck122 = 0 time = 1230
* CHECK dout0_6 vdout0_6ck122 = 3.3 time = 1230
* CHECK dout0_7 vdout0_7ck122 = 3.3 time = 1230
* CHECK dout0_8 vdout0_8ck122 = 3.3 time = 1230
* CHECK dout0_9 vdout0_9ck122 = 0 time = 1230
* CHECK dout0_10 vdout0_10ck122 = 3.3 time = 1230
* CHECK dout0_11 vdout0_11ck122 = 0 time = 1230
* CHECK dout0_12 vdout0_12ck122 = 3.3 time = 1230
* CHECK dout0_13 vdout0_13ck122 = 0 time = 1230
* CHECK dout0_14 vdout0_14ck122 = 3.3 time = 1230
* CHECK dout0_15 vdout0_15ck122 = 0 time = 1230
* CHECK dout0_16 vdout0_16ck122 = 3.3 time = 1230
* CHECK dout0_17 vdout0_17ck122 = 3.3 time = 1230
* CHECK dout0_18 vdout0_18ck122 = 3.3 time = 1230
* CHECK dout0_19 vdout0_19ck122 = 3.3 time = 1230
* CHECK dout0_20 vdout0_20ck122 = 3.3 time = 1230
* CHECK dout0_21 vdout0_21ck122 = 3.3 time = 1230
* CHECK dout0_22 vdout0_22ck122 = 0 time = 1230
* CHECK dout0_23 vdout0_23ck122 = 3.3 time = 1230
* CHECK dout0_24 vdout0_24ck122 = 0 time = 1230
* CHECK dout0_25 vdout0_25ck122 = 3.3 time = 1230
* CHECK dout0_26 vdout0_26ck122 = 3.3 time = 1230
* CHECK dout0_27 vdout0_27ck122 = 3.3 time = 1230
* CHECK dout0_28 vdout0_28ck122 = 0 time = 1230
* CHECK dout0_29 vdout0_29ck122 = 0 time = 1230
* CHECK dout0_30 vdout0_30ck122 = 0 time = 1230
* CHECK dout0_31 vdout0_31ck122 = 3.3 time = 1230
* CHECK dout0_32 vdout0_32ck122 = 0 time = 1230
* CHECK dout0_0 vdout0_0ck123 = 3.3 time = 1240
* CHECK dout0_1 vdout0_1ck123 = 0 time = 1240
* CHECK dout0_2 vdout0_2ck123 = 3.3 time = 1240
* CHECK dout0_3 vdout0_3ck123 = 0 time = 1240
* CHECK dout0_4 vdout0_4ck123 = 0 time = 1240
* CHECK dout0_5 vdout0_5ck123 = 0 time = 1240
* CHECK dout0_6 vdout0_6ck123 = 3.3 time = 1240
* CHECK dout0_7 vdout0_7ck123 = 3.3 time = 1240
* CHECK dout0_8 vdout0_8ck123 = 3.3 time = 1240
* CHECK dout0_9 vdout0_9ck123 = 0 time = 1240
* CHECK dout0_10 vdout0_10ck123 = 3.3 time = 1240
* CHECK dout0_11 vdout0_11ck123 = 0 time = 1240
* CHECK dout0_12 vdout0_12ck123 = 3.3 time = 1240
* CHECK dout0_13 vdout0_13ck123 = 0 time = 1240
* CHECK dout0_14 vdout0_14ck123 = 3.3 time = 1240
* CHECK dout0_15 vdout0_15ck123 = 0 time = 1240
* CHECK dout0_16 vdout0_16ck123 = 3.3 time = 1240
* CHECK dout0_17 vdout0_17ck123 = 3.3 time = 1240
* CHECK dout0_18 vdout0_18ck123 = 3.3 time = 1240
* CHECK dout0_19 vdout0_19ck123 = 3.3 time = 1240
* CHECK dout0_20 vdout0_20ck123 = 3.3 time = 1240
* CHECK dout0_21 vdout0_21ck123 = 3.3 time = 1240
* CHECK dout0_22 vdout0_22ck123 = 0 time = 1240
* CHECK dout0_23 vdout0_23ck123 = 3.3 time = 1240
* CHECK dout0_24 vdout0_24ck123 = 0 time = 1240
* CHECK dout0_25 vdout0_25ck123 = 3.3 time = 1240
* CHECK dout0_26 vdout0_26ck123 = 3.3 time = 1240
* CHECK dout0_27 vdout0_27ck123 = 3.3 time = 1240
* CHECK dout0_28 vdout0_28ck123 = 0 time = 1240
* CHECK dout0_29 vdout0_29ck123 = 0 time = 1240
* CHECK dout0_30 vdout0_30ck123 = 0 time = 1240
* CHECK dout0_31 vdout0_31ck123 = 3.3 time = 1240
* CHECK dout0_32 vdout0_32ck123 = 0 time = 1240
* CHECK dout0_0 vdout0_0ck124 = 3.3 time = 1250
* CHECK dout0_1 vdout0_1ck124 = 0 time = 1250
* CHECK dout0_2 vdout0_2ck124 = 3.3 time = 1250
* CHECK dout0_3 vdout0_3ck124 = 0 time = 1250
* CHECK dout0_4 vdout0_4ck124 = 0 time = 1250
* CHECK dout0_5 vdout0_5ck124 = 0 time = 1250
* CHECK dout0_6 vdout0_6ck124 = 3.3 time = 1250
* CHECK dout0_7 vdout0_7ck124 = 3.3 time = 1250
* CHECK dout0_8 vdout0_8ck124 = 3.3 time = 1250
* CHECK dout0_9 vdout0_9ck124 = 0 time = 1250
* CHECK dout0_10 vdout0_10ck124 = 3.3 time = 1250
* CHECK dout0_11 vdout0_11ck124 = 0 time = 1250
* CHECK dout0_12 vdout0_12ck124 = 3.3 time = 1250
* CHECK dout0_13 vdout0_13ck124 = 0 time = 1250
* CHECK dout0_14 vdout0_14ck124 = 3.3 time = 1250
* CHECK dout0_15 vdout0_15ck124 = 0 time = 1250
* CHECK dout0_16 vdout0_16ck124 = 3.3 time = 1250
* CHECK dout0_17 vdout0_17ck124 = 3.3 time = 1250
* CHECK dout0_18 vdout0_18ck124 = 3.3 time = 1250
* CHECK dout0_19 vdout0_19ck124 = 3.3 time = 1250
* CHECK dout0_20 vdout0_20ck124 = 3.3 time = 1250
* CHECK dout0_21 vdout0_21ck124 = 3.3 time = 1250
* CHECK dout0_22 vdout0_22ck124 = 0 time = 1250
* CHECK dout0_23 vdout0_23ck124 = 3.3 time = 1250
* CHECK dout0_24 vdout0_24ck124 = 0 time = 1250
* CHECK dout0_25 vdout0_25ck124 = 3.3 time = 1250
* CHECK dout0_26 vdout0_26ck124 = 3.3 time = 1250
* CHECK dout0_27 vdout0_27ck124 = 3.3 time = 1250
* CHECK dout0_28 vdout0_28ck124 = 0 time = 1250
* CHECK dout0_29 vdout0_29ck124 = 0 time = 1250
* CHECK dout0_30 vdout0_30ck124 = 0 time = 1250
* CHECK dout0_31 vdout0_31ck124 = 3.3 time = 1250
* CHECK dout0_32 vdout0_32ck124 = 0 time = 1250
* CHECK dout0_0 vdout0_0ck125 = 3.3 time = 1260
* CHECK dout0_1 vdout0_1ck125 = 0 time = 1260
* CHECK dout0_2 vdout0_2ck125 = 3.3 time = 1260
* CHECK dout0_3 vdout0_3ck125 = 0 time = 1260
* CHECK dout0_4 vdout0_4ck125 = 0 time = 1260
* CHECK dout0_5 vdout0_5ck125 = 0 time = 1260
* CHECK dout0_6 vdout0_6ck125 = 3.3 time = 1260
* CHECK dout0_7 vdout0_7ck125 = 3.3 time = 1260
* CHECK dout0_8 vdout0_8ck125 = 3.3 time = 1260
* CHECK dout0_9 vdout0_9ck125 = 0 time = 1260
* CHECK dout0_10 vdout0_10ck125 = 3.3 time = 1260
* CHECK dout0_11 vdout0_11ck125 = 0 time = 1260
* CHECK dout0_12 vdout0_12ck125 = 3.3 time = 1260
* CHECK dout0_13 vdout0_13ck125 = 0 time = 1260
* CHECK dout0_14 vdout0_14ck125 = 3.3 time = 1260
* CHECK dout0_15 vdout0_15ck125 = 0 time = 1260
* CHECK dout0_16 vdout0_16ck125 = 3.3 time = 1260
* CHECK dout0_17 vdout0_17ck125 = 3.3 time = 1260
* CHECK dout0_18 vdout0_18ck125 = 3.3 time = 1260
* CHECK dout0_19 vdout0_19ck125 = 3.3 time = 1260
* CHECK dout0_20 vdout0_20ck125 = 3.3 time = 1260
* CHECK dout0_21 vdout0_21ck125 = 3.3 time = 1260
* CHECK dout0_22 vdout0_22ck125 = 0 time = 1260
* CHECK dout0_23 vdout0_23ck125 = 3.3 time = 1260
* CHECK dout0_24 vdout0_24ck125 = 0 time = 1260
* CHECK dout0_25 vdout0_25ck125 = 3.3 time = 1260
* CHECK dout0_26 vdout0_26ck125 = 3.3 time = 1260
* CHECK dout0_27 vdout0_27ck125 = 3.3 time = 1260
* CHECK dout0_28 vdout0_28ck125 = 0 time = 1260
* CHECK dout0_29 vdout0_29ck125 = 0 time = 1260
* CHECK dout0_30 vdout0_30ck125 = 0 time = 1260
* CHECK dout0_31 vdout0_31ck125 = 3.3 time = 1260
* CHECK dout0_32 vdout0_32ck125 = 0 time = 1260
* CHECK dout0_0 vdout0_0ck126 = 3.3 time = 1270
* CHECK dout0_1 vdout0_1ck126 = 0 time = 1270
* CHECK dout0_2 vdout0_2ck126 = 3.3 time = 1270
* CHECK dout0_3 vdout0_3ck126 = 0 time = 1270
* CHECK dout0_4 vdout0_4ck126 = 0 time = 1270
* CHECK dout0_5 vdout0_5ck126 = 0 time = 1270
* CHECK dout0_6 vdout0_6ck126 = 3.3 time = 1270
* CHECK dout0_7 vdout0_7ck126 = 3.3 time = 1270
* CHECK dout0_8 vdout0_8ck126 = 3.3 time = 1270
* CHECK dout0_9 vdout0_9ck126 = 0 time = 1270
* CHECK dout0_10 vdout0_10ck126 = 3.3 time = 1270
* CHECK dout0_11 vdout0_11ck126 = 0 time = 1270
* CHECK dout0_12 vdout0_12ck126 = 3.3 time = 1270
* CHECK dout0_13 vdout0_13ck126 = 0 time = 1270
* CHECK dout0_14 vdout0_14ck126 = 3.3 time = 1270
* CHECK dout0_15 vdout0_15ck126 = 0 time = 1270
* CHECK dout0_16 vdout0_16ck126 = 3.3 time = 1270
* CHECK dout0_17 vdout0_17ck126 = 3.3 time = 1270
* CHECK dout0_18 vdout0_18ck126 = 3.3 time = 1270
* CHECK dout0_19 vdout0_19ck126 = 3.3 time = 1270
* CHECK dout0_20 vdout0_20ck126 = 3.3 time = 1270
* CHECK dout0_21 vdout0_21ck126 = 3.3 time = 1270
* CHECK dout0_22 vdout0_22ck126 = 0 time = 1270
* CHECK dout0_23 vdout0_23ck126 = 3.3 time = 1270
* CHECK dout0_24 vdout0_24ck126 = 0 time = 1270
* CHECK dout0_25 vdout0_25ck126 = 3.3 time = 1270
* CHECK dout0_26 vdout0_26ck126 = 3.3 time = 1270
* CHECK dout0_27 vdout0_27ck126 = 3.3 time = 1270
* CHECK dout0_28 vdout0_28ck126 = 0 time = 1270
* CHECK dout0_29 vdout0_29ck126 = 0 time = 1270
* CHECK dout0_30 vdout0_30ck126 = 0 time = 1270
* CHECK dout0_31 vdout0_31ck126 = 3.3 time = 1270
* CHECK dout0_32 vdout0_32ck126 = 0 time = 1270
* CHECK dout0_0 vdout0_0ck128 = 0 time = 1290
* CHECK dout0_1 vdout0_1ck128 = 0 time = 1290
* CHECK dout0_2 vdout0_2ck128 = 3.3 time = 1290
* CHECK dout0_3 vdout0_3ck128 = 0 time = 1290
* CHECK dout0_4 vdout0_4ck128 = 0 time = 1290
* CHECK dout0_5 vdout0_5ck128 = 0 time = 1290
* CHECK dout0_6 vdout0_6ck128 = 3.3 time = 1290
* CHECK dout0_7 vdout0_7ck128 = 3.3 time = 1290
* CHECK dout0_8 vdout0_8ck128 = 0 time = 1290
* CHECK dout0_9 vdout0_9ck128 = 3.3 time = 1290
* CHECK dout0_10 vdout0_10ck128 = 3.3 time = 1290
* CHECK dout0_11 vdout0_11ck128 = 0 time = 1290
* CHECK dout0_12 vdout0_12ck128 = 0 time = 1290
* CHECK dout0_13 vdout0_13ck128 = 3.3 time = 1290
* CHECK dout0_14 vdout0_14ck128 = 3.3 time = 1290
* CHECK dout0_15 vdout0_15ck128 = 0 time = 1290
* CHECK dout0_16 vdout0_16ck128 = 0 time = 1290
* CHECK dout0_17 vdout0_17ck128 = 3.3 time = 1290
* CHECK dout0_18 vdout0_18ck128 = 3.3 time = 1290
* CHECK dout0_19 vdout0_19ck128 = 0 time = 1290
* CHECK dout0_20 vdout0_20ck128 = 3.3 time = 1290
* CHECK dout0_21 vdout0_21ck128 = 0 time = 1290
* CHECK dout0_22 vdout0_22ck128 = 3.3 time = 1290
* CHECK dout0_23 vdout0_23ck128 = 3.3 time = 1290
* CHECK dout0_24 vdout0_24ck128 = 0 time = 1290
* CHECK dout0_25 vdout0_25ck128 = 0 time = 1290
* CHECK dout0_26 vdout0_26ck128 = 3.3 time = 1290
* CHECK dout0_27 vdout0_27ck128 = 3.3 time = 1290
* CHECK dout0_28 vdout0_28ck128 = 3.3 time = 1290
* CHECK dout0_29 vdout0_29ck128 = 0 time = 1290
* CHECK dout0_30 vdout0_30ck128 = 0 time = 1290
* CHECK dout0_31 vdout0_31ck128 = 0 time = 1290
* CHECK dout0_32 vdout0_32ck128 = 0 time = 1290
* CHECK dout0_0 vdout0_0ck131 = 3.3 time = 1320
* CHECK dout0_1 vdout0_1ck131 = 0 time = 1320
* CHECK dout0_2 vdout0_2ck131 = 3.3 time = 1320
* CHECK dout0_3 vdout0_3ck131 = 0 time = 1320
* CHECK dout0_4 vdout0_4ck131 = 0 time = 1320
* CHECK dout0_5 vdout0_5ck131 = 0 time = 1320
* CHECK dout0_6 vdout0_6ck131 = 3.3 time = 1320
* CHECK dout0_7 vdout0_7ck131 = 3.3 time = 1320
* CHECK dout0_8 vdout0_8ck131 = 3.3 time = 1320
* CHECK dout0_9 vdout0_9ck131 = 0 time = 1320
* CHECK dout0_10 vdout0_10ck131 = 3.3 time = 1320
* CHECK dout0_11 vdout0_11ck131 = 0 time = 1320
* CHECK dout0_12 vdout0_12ck131 = 3.3 time = 1320
* CHECK dout0_13 vdout0_13ck131 = 0 time = 1320
* CHECK dout0_14 vdout0_14ck131 = 3.3 time = 1320
* CHECK dout0_15 vdout0_15ck131 = 0 time = 1320
* CHECK dout0_16 vdout0_16ck131 = 3.3 time = 1320
* CHECK dout0_17 vdout0_17ck131 = 3.3 time = 1320
* CHECK dout0_18 vdout0_18ck131 = 3.3 time = 1320
* CHECK dout0_19 vdout0_19ck131 = 3.3 time = 1320
* CHECK dout0_20 vdout0_20ck131 = 3.3 time = 1320
* CHECK dout0_21 vdout0_21ck131 = 3.3 time = 1320
* CHECK dout0_22 vdout0_22ck131 = 0 time = 1320
* CHECK dout0_23 vdout0_23ck131 = 3.3 time = 1320
* CHECK dout0_24 vdout0_24ck131 = 0 time = 1320
* CHECK dout0_25 vdout0_25ck131 = 3.3 time = 1320
* CHECK dout0_26 vdout0_26ck131 = 3.3 time = 1320
* CHECK dout0_27 vdout0_27ck131 = 3.3 time = 1320
* CHECK dout0_28 vdout0_28ck131 = 0 time = 1320
* CHECK dout0_29 vdout0_29ck131 = 0 time = 1320
* CHECK dout0_30 vdout0_30ck131 = 0 time = 1320
* CHECK dout0_31 vdout0_31ck131 = 3.3 time = 1320
* CHECK dout0_32 vdout0_32ck131 = 0 time = 1320
* CHECK dout0_0 vdout0_0ck132 = 0 time = 1330
* CHECK dout0_1 vdout0_1ck132 = 3.3 time = 1330
* CHECK dout0_2 vdout0_2ck132 = 3.3 time = 1330
* CHECK dout0_3 vdout0_3ck132 = 0 time = 1330
* CHECK dout0_4 vdout0_4ck132 = 3.3 time = 1330
* CHECK dout0_5 vdout0_5ck132 = 3.3 time = 1330
* CHECK dout0_6 vdout0_6ck132 = 3.3 time = 1330
* CHECK dout0_7 vdout0_7ck132 = 0 time = 1330
* CHECK dout0_8 vdout0_8ck132 = 0 time = 1330
* CHECK dout0_9 vdout0_9ck132 = 3.3 time = 1330
* CHECK dout0_10 vdout0_10ck132 = 3.3 time = 1330
* CHECK dout0_11 vdout0_11ck132 = 3.3 time = 1330
* CHECK dout0_12 vdout0_12ck132 = 0 time = 1330
* CHECK dout0_13 vdout0_13ck132 = 3.3 time = 1330
* CHECK dout0_14 vdout0_14ck132 = 3.3 time = 1330
* CHECK dout0_15 vdout0_15ck132 = 0 time = 1330
* CHECK dout0_16 vdout0_16ck132 = 0 time = 1330
* CHECK dout0_17 vdout0_17ck132 = 0 time = 1330
* CHECK dout0_18 vdout0_18ck132 = 3.3 time = 1330
* CHECK dout0_19 vdout0_19ck132 = 0 time = 1330
* CHECK dout0_20 vdout0_20ck132 = 3.3 time = 1330
* CHECK dout0_21 vdout0_21ck132 = 0 time = 1330
* CHECK dout0_22 vdout0_22ck132 = 3.3 time = 1330
* CHECK dout0_23 vdout0_23ck132 = 3.3 time = 1330
* CHECK dout0_24 vdout0_24ck132 = 0 time = 1330
* CHECK dout0_25 vdout0_25ck132 = 3.3 time = 1330
* CHECK dout0_26 vdout0_26ck132 = 0 time = 1330
* CHECK dout0_27 vdout0_27ck132 = 3.3 time = 1330
* CHECK dout0_28 vdout0_28ck132 = 3.3 time = 1330
* CHECK dout0_29 vdout0_29ck132 = 0 time = 1330
* CHECK dout0_30 vdout0_30ck132 = 0 time = 1330
* CHECK dout0_31 vdout0_31ck132 = 3.3 time = 1330
* CHECK dout0_32 vdout0_32ck132 = 0 time = 1330
* CHECK dout0_0 vdout0_0ck133 = 3.3 time = 1340
* CHECK dout0_1 vdout0_1ck133 = 0 time = 1340
* CHECK dout0_2 vdout0_2ck133 = 3.3 time = 1340
* CHECK dout0_3 vdout0_3ck133 = 0 time = 1340
* CHECK dout0_4 vdout0_4ck133 = 0 time = 1340
* CHECK dout0_5 vdout0_5ck133 = 0 time = 1340
* CHECK dout0_6 vdout0_6ck133 = 3.3 time = 1340
* CHECK dout0_7 vdout0_7ck133 = 3.3 time = 1340
* CHECK dout0_8 vdout0_8ck133 = 3.3 time = 1340
* CHECK dout0_9 vdout0_9ck133 = 0 time = 1340
* CHECK dout0_10 vdout0_10ck133 = 3.3 time = 1340
* CHECK dout0_11 vdout0_11ck133 = 0 time = 1340
* CHECK dout0_12 vdout0_12ck133 = 3.3 time = 1340
* CHECK dout0_13 vdout0_13ck133 = 0 time = 1340
* CHECK dout0_14 vdout0_14ck133 = 3.3 time = 1340
* CHECK dout0_15 vdout0_15ck133 = 0 time = 1340
* CHECK dout0_16 vdout0_16ck133 = 3.3 time = 1340
* CHECK dout0_17 vdout0_17ck133 = 3.3 time = 1340
* CHECK dout0_18 vdout0_18ck133 = 3.3 time = 1340
* CHECK dout0_19 vdout0_19ck133 = 3.3 time = 1340
* CHECK dout0_20 vdout0_20ck133 = 3.3 time = 1340
* CHECK dout0_21 vdout0_21ck133 = 3.3 time = 1340
* CHECK dout0_22 vdout0_22ck133 = 0 time = 1340
* CHECK dout0_23 vdout0_23ck133 = 3.3 time = 1340
* CHECK dout0_24 vdout0_24ck133 = 0 time = 1340
* CHECK dout0_25 vdout0_25ck133 = 3.3 time = 1340
* CHECK dout0_26 vdout0_26ck133 = 3.3 time = 1340
* CHECK dout0_27 vdout0_27ck133 = 3.3 time = 1340
* CHECK dout0_28 vdout0_28ck133 = 0 time = 1340
* CHECK dout0_29 vdout0_29ck133 = 0 time = 1340
* CHECK dout0_30 vdout0_30ck133 = 0 time = 1340
* CHECK dout0_31 vdout0_31ck133 = 3.3 time = 1340
* CHECK dout0_32 vdout0_32ck133 = 0 time = 1340
* CHECK dout0_0 vdout0_0ck134 = 0 time = 1350
* CHECK dout0_1 vdout0_1ck134 = 3.3 time = 1350
* CHECK dout0_2 vdout0_2ck134 = 3.3 time = 1350
* CHECK dout0_3 vdout0_3ck134 = 0 time = 1350
* CHECK dout0_4 vdout0_4ck134 = 3.3 time = 1350
* CHECK dout0_5 vdout0_5ck134 = 3.3 time = 1350
* CHECK dout0_6 vdout0_6ck134 = 3.3 time = 1350
* CHECK dout0_7 vdout0_7ck134 = 0 time = 1350
* CHECK dout0_8 vdout0_8ck134 = 0 time = 1350
* CHECK dout0_9 vdout0_9ck134 = 3.3 time = 1350
* CHECK dout0_10 vdout0_10ck134 = 3.3 time = 1350
* CHECK dout0_11 vdout0_11ck134 = 3.3 time = 1350
* CHECK dout0_12 vdout0_12ck134 = 0 time = 1350
* CHECK dout0_13 vdout0_13ck134 = 3.3 time = 1350
* CHECK dout0_14 vdout0_14ck134 = 3.3 time = 1350
* CHECK dout0_15 vdout0_15ck134 = 0 time = 1350
* CHECK dout0_16 vdout0_16ck134 = 0 time = 1350
* CHECK dout0_17 vdout0_17ck134 = 0 time = 1350
* CHECK dout0_18 vdout0_18ck134 = 3.3 time = 1350
* CHECK dout0_19 vdout0_19ck134 = 0 time = 1350
* CHECK dout0_20 vdout0_20ck134 = 3.3 time = 1350
* CHECK dout0_21 vdout0_21ck134 = 0 time = 1350
* CHECK dout0_22 vdout0_22ck134 = 3.3 time = 1350
* CHECK dout0_23 vdout0_23ck134 = 3.3 time = 1350
* CHECK dout0_24 vdout0_24ck134 = 0 time = 1350
* CHECK dout0_25 vdout0_25ck134 = 3.3 time = 1350
* CHECK dout0_26 vdout0_26ck134 = 0 time = 1350
* CHECK dout0_27 vdout0_27ck134 = 3.3 time = 1350
* CHECK dout0_28 vdout0_28ck134 = 3.3 time = 1350
* CHECK dout0_29 vdout0_29ck134 = 0 time = 1350
* CHECK dout0_30 vdout0_30ck134 = 0 time = 1350
* CHECK dout0_31 vdout0_31ck134 = 3.3 time = 1350
* CHECK dout0_32 vdout0_32ck134 = 0 time = 1350
* CHECK dout0_0 vdout0_0ck135 = 0 time = 1360
* CHECK dout0_1 vdout0_1ck135 = 3.3 time = 1360
* CHECK dout0_2 vdout0_2ck135 = 3.3 time = 1360
* CHECK dout0_3 vdout0_3ck135 = 0 time = 1360
* CHECK dout0_4 vdout0_4ck135 = 3.3 time = 1360
* CHECK dout0_5 vdout0_5ck135 = 3.3 time = 1360
* CHECK dout0_6 vdout0_6ck135 = 3.3 time = 1360
* CHECK dout0_7 vdout0_7ck135 = 0 time = 1360
* CHECK dout0_8 vdout0_8ck135 = 0 time = 1360
* CHECK dout0_9 vdout0_9ck135 = 3.3 time = 1360
* CHECK dout0_10 vdout0_10ck135 = 3.3 time = 1360
* CHECK dout0_11 vdout0_11ck135 = 3.3 time = 1360
* CHECK dout0_12 vdout0_12ck135 = 0 time = 1360
* CHECK dout0_13 vdout0_13ck135 = 3.3 time = 1360
* CHECK dout0_14 vdout0_14ck135 = 3.3 time = 1360
* CHECK dout0_15 vdout0_15ck135 = 0 time = 1360
* CHECK dout0_16 vdout0_16ck135 = 0 time = 1360
* CHECK dout0_17 vdout0_17ck135 = 0 time = 1360
* CHECK dout0_18 vdout0_18ck135 = 3.3 time = 1360
* CHECK dout0_19 vdout0_19ck135 = 0 time = 1360
* CHECK dout0_20 vdout0_20ck135 = 3.3 time = 1360
* CHECK dout0_21 vdout0_21ck135 = 0 time = 1360
* CHECK dout0_22 vdout0_22ck135 = 3.3 time = 1360
* CHECK dout0_23 vdout0_23ck135 = 3.3 time = 1360
* CHECK dout0_24 vdout0_24ck135 = 0 time = 1360
* CHECK dout0_25 vdout0_25ck135 = 3.3 time = 1360
* CHECK dout0_26 vdout0_26ck135 = 0 time = 1360
* CHECK dout0_27 vdout0_27ck135 = 3.3 time = 1360
* CHECK dout0_28 vdout0_28ck135 = 3.3 time = 1360
* CHECK dout0_29 vdout0_29ck135 = 0 time = 1360
* CHECK dout0_30 vdout0_30ck135 = 0 time = 1360
* CHECK dout0_31 vdout0_31ck135 = 3.3 time = 1360
* CHECK dout0_32 vdout0_32ck135 = 0 time = 1360
* CHECK dout0_0 vdout0_0ck136 = 0 time = 1370
* CHECK dout0_1 vdout0_1ck136 = 3.3 time = 1370
* CHECK dout0_2 vdout0_2ck136 = 3.3 time = 1370
* CHECK dout0_3 vdout0_3ck136 = 0 time = 1370
* CHECK dout0_4 vdout0_4ck136 = 3.3 time = 1370
* CHECK dout0_5 vdout0_5ck136 = 3.3 time = 1370
* CHECK dout0_6 vdout0_6ck136 = 3.3 time = 1370
* CHECK dout0_7 vdout0_7ck136 = 0 time = 1370
* CHECK dout0_8 vdout0_8ck136 = 0 time = 1370
* CHECK dout0_9 vdout0_9ck136 = 3.3 time = 1370
* CHECK dout0_10 vdout0_10ck136 = 3.3 time = 1370
* CHECK dout0_11 vdout0_11ck136 = 3.3 time = 1370
* CHECK dout0_12 vdout0_12ck136 = 0 time = 1370
* CHECK dout0_13 vdout0_13ck136 = 3.3 time = 1370
* CHECK dout0_14 vdout0_14ck136 = 3.3 time = 1370
* CHECK dout0_15 vdout0_15ck136 = 0 time = 1370
* CHECK dout0_16 vdout0_16ck136 = 0 time = 1370
* CHECK dout0_17 vdout0_17ck136 = 0 time = 1370
* CHECK dout0_18 vdout0_18ck136 = 3.3 time = 1370
* CHECK dout0_19 vdout0_19ck136 = 0 time = 1370
* CHECK dout0_20 vdout0_20ck136 = 3.3 time = 1370
* CHECK dout0_21 vdout0_21ck136 = 0 time = 1370
* CHECK dout0_22 vdout0_22ck136 = 3.3 time = 1370
* CHECK dout0_23 vdout0_23ck136 = 3.3 time = 1370
* CHECK dout0_24 vdout0_24ck136 = 0 time = 1370
* CHECK dout0_25 vdout0_25ck136 = 3.3 time = 1370
* CHECK dout0_26 vdout0_26ck136 = 0 time = 1370
* CHECK dout0_27 vdout0_27ck136 = 3.3 time = 1370
* CHECK dout0_28 vdout0_28ck136 = 3.3 time = 1370
* CHECK dout0_29 vdout0_29ck136 = 0 time = 1370
* CHECK dout0_30 vdout0_30ck136 = 0 time = 1370
* CHECK dout0_31 vdout0_31ck136 = 3.3 time = 1370
* CHECK dout0_32 vdout0_32ck136 = 0 time = 1370
* CHECK dout0_0 vdout0_0ck137 = 0 time = 1380
* CHECK dout0_1 vdout0_1ck137 = 3.3 time = 1380
* CHECK dout0_2 vdout0_2ck137 = 3.3 time = 1380
* CHECK dout0_3 vdout0_3ck137 = 0 time = 1380
* CHECK dout0_4 vdout0_4ck137 = 3.3 time = 1380
* CHECK dout0_5 vdout0_5ck137 = 3.3 time = 1380
* CHECK dout0_6 vdout0_6ck137 = 3.3 time = 1380
* CHECK dout0_7 vdout0_7ck137 = 0 time = 1380
* CHECK dout0_8 vdout0_8ck137 = 0 time = 1380
* CHECK dout0_9 vdout0_9ck137 = 3.3 time = 1380
* CHECK dout0_10 vdout0_10ck137 = 3.3 time = 1380
* CHECK dout0_11 vdout0_11ck137 = 3.3 time = 1380
* CHECK dout0_12 vdout0_12ck137 = 0 time = 1380
* CHECK dout0_13 vdout0_13ck137 = 3.3 time = 1380
* CHECK dout0_14 vdout0_14ck137 = 3.3 time = 1380
* CHECK dout0_15 vdout0_15ck137 = 0 time = 1380
* CHECK dout0_16 vdout0_16ck137 = 0 time = 1380
* CHECK dout0_17 vdout0_17ck137 = 0 time = 1380
* CHECK dout0_18 vdout0_18ck137 = 3.3 time = 1380
* CHECK dout0_19 vdout0_19ck137 = 0 time = 1380
* CHECK dout0_20 vdout0_20ck137 = 3.3 time = 1380
* CHECK dout0_21 vdout0_21ck137 = 0 time = 1380
* CHECK dout0_22 vdout0_22ck137 = 3.3 time = 1380
* CHECK dout0_23 vdout0_23ck137 = 3.3 time = 1380
* CHECK dout0_24 vdout0_24ck137 = 0 time = 1380
* CHECK dout0_25 vdout0_25ck137 = 3.3 time = 1380
* CHECK dout0_26 vdout0_26ck137 = 0 time = 1380
* CHECK dout0_27 vdout0_27ck137 = 3.3 time = 1380
* CHECK dout0_28 vdout0_28ck137 = 3.3 time = 1380
* CHECK dout0_29 vdout0_29ck137 = 0 time = 1380
* CHECK dout0_30 vdout0_30ck137 = 0 time = 1380
* CHECK dout0_31 vdout0_31ck137 = 3.3 time = 1380
* CHECK dout0_32 vdout0_32ck137 = 0 time = 1380
* CHECK dout0_0 vdout0_0ck138 = 3.3 time = 1390
* CHECK dout0_1 vdout0_1ck138 = 0 time = 1390
* CHECK dout0_2 vdout0_2ck138 = 3.3 time = 1390
* CHECK dout0_3 vdout0_3ck138 = 0 time = 1390
* CHECK dout0_4 vdout0_4ck138 = 0 time = 1390
* CHECK dout0_5 vdout0_5ck138 = 0 time = 1390
* CHECK dout0_6 vdout0_6ck138 = 3.3 time = 1390
* CHECK dout0_7 vdout0_7ck138 = 3.3 time = 1390
* CHECK dout0_8 vdout0_8ck138 = 3.3 time = 1390
* CHECK dout0_9 vdout0_9ck138 = 0 time = 1390
* CHECK dout0_10 vdout0_10ck138 = 3.3 time = 1390
* CHECK dout0_11 vdout0_11ck138 = 0 time = 1390
* CHECK dout0_12 vdout0_12ck138 = 3.3 time = 1390
* CHECK dout0_13 vdout0_13ck138 = 0 time = 1390
* CHECK dout0_14 vdout0_14ck138 = 3.3 time = 1390
* CHECK dout0_15 vdout0_15ck138 = 0 time = 1390
* CHECK dout0_16 vdout0_16ck138 = 3.3 time = 1390
* CHECK dout0_17 vdout0_17ck138 = 3.3 time = 1390
* CHECK dout0_18 vdout0_18ck138 = 3.3 time = 1390
* CHECK dout0_19 vdout0_19ck138 = 3.3 time = 1390
* CHECK dout0_20 vdout0_20ck138 = 3.3 time = 1390
* CHECK dout0_21 vdout0_21ck138 = 3.3 time = 1390
* CHECK dout0_22 vdout0_22ck138 = 0 time = 1390
* CHECK dout0_23 vdout0_23ck138 = 3.3 time = 1390
* CHECK dout0_24 vdout0_24ck138 = 0 time = 1390
* CHECK dout0_25 vdout0_25ck138 = 3.3 time = 1390
* CHECK dout0_26 vdout0_26ck138 = 3.3 time = 1390
* CHECK dout0_27 vdout0_27ck138 = 3.3 time = 1390
* CHECK dout0_28 vdout0_28ck138 = 0 time = 1390
* CHECK dout0_29 vdout0_29ck138 = 0 time = 1390
* CHECK dout0_30 vdout0_30ck138 = 0 time = 1390
* CHECK dout0_31 vdout0_31ck138 = 3.3 time = 1390
* CHECK dout0_32 vdout0_32ck138 = 0 time = 1390
* CHECK dout0_0 vdout0_0ck139 = 3.3 time = 1400
* CHECK dout0_1 vdout0_1ck139 = 0 time = 1400
* CHECK dout0_2 vdout0_2ck139 = 3.3 time = 1400
* CHECK dout0_3 vdout0_3ck139 = 0 time = 1400
* CHECK dout0_4 vdout0_4ck139 = 0 time = 1400
* CHECK dout0_5 vdout0_5ck139 = 0 time = 1400
* CHECK dout0_6 vdout0_6ck139 = 3.3 time = 1400
* CHECK dout0_7 vdout0_7ck139 = 3.3 time = 1400
* CHECK dout0_8 vdout0_8ck139 = 3.3 time = 1400
* CHECK dout0_9 vdout0_9ck139 = 0 time = 1400
* CHECK dout0_10 vdout0_10ck139 = 3.3 time = 1400
* CHECK dout0_11 vdout0_11ck139 = 0 time = 1400
* CHECK dout0_12 vdout0_12ck139 = 3.3 time = 1400
* CHECK dout0_13 vdout0_13ck139 = 0 time = 1400
* CHECK dout0_14 vdout0_14ck139 = 3.3 time = 1400
* CHECK dout0_15 vdout0_15ck139 = 0 time = 1400
* CHECK dout0_16 vdout0_16ck139 = 3.3 time = 1400
* CHECK dout0_17 vdout0_17ck139 = 3.3 time = 1400
* CHECK dout0_18 vdout0_18ck139 = 3.3 time = 1400
* CHECK dout0_19 vdout0_19ck139 = 3.3 time = 1400
* CHECK dout0_20 vdout0_20ck139 = 3.3 time = 1400
* CHECK dout0_21 vdout0_21ck139 = 3.3 time = 1400
* CHECK dout0_22 vdout0_22ck139 = 0 time = 1400
* CHECK dout0_23 vdout0_23ck139 = 3.3 time = 1400
* CHECK dout0_24 vdout0_24ck139 = 0 time = 1400
* CHECK dout0_25 vdout0_25ck139 = 3.3 time = 1400
* CHECK dout0_26 vdout0_26ck139 = 3.3 time = 1400
* CHECK dout0_27 vdout0_27ck139 = 3.3 time = 1400
* CHECK dout0_28 vdout0_28ck139 = 0 time = 1400
* CHECK dout0_29 vdout0_29ck139 = 0 time = 1400
* CHECK dout0_30 vdout0_30ck139 = 0 time = 1400
* CHECK dout0_31 vdout0_31ck139 = 3.3 time = 1400
* CHECK dout0_32 vdout0_32ck139 = 0 time = 1400
* CHECK dout0_0 vdout0_0ck140 = 3.3 time = 1410
* CHECK dout0_1 vdout0_1ck140 = 0 time = 1410
* CHECK dout0_2 vdout0_2ck140 = 3.3 time = 1410
* CHECK dout0_3 vdout0_3ck140 = 0 time = 1410
* CHECK dout0_4 vdout0_4ck140 = 0 time = 1410
* CHECK dout0_5 vdout0_5ck140 = 0 time = 1410
* CHECK dout0_6 vdout0_6ck140 = 3.3 time = 1410
* CHECK dout0_7 vdout0_7ck140 = 3.3 time = 1410
* CHECK dout0_8 vdout0_8ck140 = 3.3 time = 1410
* CHECK dout0_9 vdout0_9ck140 = 0 time = 1410
* CHECK dout0_10 vdout0_10ck140 = 3.3 time = 1410
* CHECK dout0_11 vdout0_11ck140 = 0 time = 1410
* CHECK dout0_12 vdout0_12ck140 = 3.3 time = 1410
* CHECK dout0_13 vdout0_13ck140 = 0 time = 1410
* CHECK dout0_14 vdout0_14ck140 = 3.3 time = 1410
* CHECK dout0_15 vdout0_15ck140 = 0 time = 1410
* CHECK dout0_16 vdout0_16ck140 = 3.3 time = 1410
* CHECK dout0_17 vdout0_17ck140 = 3.3 time = 1410
* CHECK dout0_18 vdout0_18ck140 = 3.3 time = 1410
* CHECK dout0_19 vdout0_19ck140 = 3.3 time = 1410
* CHECK dout0_20 vdout0_20ck140 = 3.3 time = 1410
* CHECK dout0_21 vdout0_21ck140 = 3.3 time = 1410
* CHECK dout0_22 vdout0_22ck140 = 0 time = 1410
* CHECK dout0_23 vdout0_23ck140 = 3.3 time = 1410
* CHECK dout0_24 vdout0_24ck140 = 0 time = 1410
* CHECK dout0_25 vdout0_25ck140 = 3.3 time = 1410
* CHECK dout0_26 vdout0_26ck140 = 3.3 time = 1410
* CHECK dout0_27 vdout0_27ck140 = 3.3 time = 1410
* CHECK dout0_28 vdout0_28ck140 = 0 time = 1410
* CHECK dout0_29 vdout0_29ck140 = 0 time = 1410
* CHECK dout0_30 vdout0_30ck140 = 0 time = 1410
* CHECK dout0_31 vdout0_31ck140 = 3.3 time = 1410
* CHECK dout0_32 vdout0_32ck140 = 0 time = 1410
* CHECK dout0_0 vdout0_0ck143 = 3.3 time = 1440
* CHECK dout0_1 vdout0_1ck143 = 3.3 time = 1440
* CHECK dout0_2 vdout0_2ck143 = 3.3 time = 1440
* CHECK dout0_3 vdout0_3ck143 = 3.3 time = 1440
* CHECK dout0_4 vdout0_4ck143 = 0 time = 1440
* CHECK dout0_5 vdout0_5ck143 = 0 time = 1440
* CHECK dout0_6 vdout0_6ck143 = 0 time = 1440
* CHECK dout0_7 vdout0_7ck143 = 0 time = 1440
* CHECK dout0_8 vdout0_8ck143 = 3.3 time = 1440
* CHECK dout0_9 vdout0_9ck143 = 3.3 time = 1440
* CHECK dout0_10 vdout0_10ck143 = 0 time = 1440
* CHECK dout0_11 vdout0_11ck143 = 3.3 time = 1440
* CHECK dout0_12 vdout0_12ck143 = 0 time = 1440
* CHECK dout0_13 vdout0_13ck143 = 0 time = 1440
* CHECK dout0_14 vdout0_14ck143 = 0 time = 1440
* CHECK dout0_15 vdout0_15ck143 = 0 time = 1440
* CHECK dout0_16 vdout0_16ck143 = 3.3 time = 1440
* CHECK dout0_17 vdout0_17ck143 = 3.3 time = 1440
* CHECK dout0_18 vdout0_18ck143 = 3.3 time = 1440
* CHECK dout0_19 vdout0_19ck143 = 3.3 time = 1440
* CHECK dout0_20 vdout0_20ck143 = 3.3 time = 1440
* CHECK dout0_21 vdout0_21ck143 = 3.3 time = 1440
* CHECK dout0_22 vdout0_22ck143 = 3.3 time = 1440
* CHECK dout0_23 vdout0_23ck143 = 3.3 time = 1440
* CHECK dout0_24 vdout0_24ck143 = 3.3 time = 1440
* CHECK dout0_25 vdout0_25ck143 = 3.3 time = 1440
* CHECK dout0_26 vdout0_26ck143 = 3.3 time = 1440
* CHECK dout0_27 vdout0_27ck143 = 3.3 time = 1440
* CHECK dout0_28 vdout0_28ck143 = 3.3 time = 1440
* CHECK dout0_29 vdout0_29ck143 = 3.3 time = 1440
* CHECK dout0_30 vdout0_30ck143 = 0 time = 1440
* CHECK dout0_31 vdout0_31ck143 = 3.3 time = 1440
* CHECK dout0_32 vdout0_32ck143 = 0 time = 1440
* CHECK dout0_0 vdout0_0ck145 = 0 time = 1460
* CHECK dout0_1 vdout0_1ck145 = 3.3 time = 1460
* CHECK dout0_2 vdout0_2ck145 = 0 time = 1460
* CHECK dout0_3 vdout0_3ck145 = 3.3 time = 1460
* CHECK dout0_4 vdout0_4ck145 = 3.3 time = 1460
* CHECK dout0_5 vdout0_5ck145 = 0 time = 1460
* CHECK dout0_6 vdout0_6ck145 = 3.3 time = 1460
* CHECK dout0_7 vdout0_7ck145 = 0 time = 1460
* CHECK dout0_8 vdout0_8ck145 = 0 time = 1460
* CHECK dout0_9 vdout0_9ck145 = 0 time = 1460
* CHECK dout0_10 vdout0_10ck145 = 0 time = 1460
* CHECK dout0_11 vdout0_11ck145 = 0 time = 1460
* CHECK dout0_12 vdout0_12ck145 = 0 time = 1460
* CHECK dout0_13 vdout0_13ck145 = 0 time = 1460
* CHECK dout0_14 vdout0_14ck145 = 3.3 time = 1460
* CHECK dout0_15 vdout0_15ck145 = 3.3 time = 1460
* CHECK dout0_16 vdout0_16ck145 = 0 time = 1460
* CHECK dout0_17 vdout0_17ck145 = 3.3 time = 1460
* CHECK dout0_18 vdout0_18ck145 = 3.3 time = 1460
* CHECK dout0_19 vdout0_19ck145 = 0 time = 1460
* CHECK dout0_20 vdout0_20ck145 = 3.3 time = 1460
* CHECK dout0_21 vdout0_21ck145 = 3.3 time = 1460
* CHECK dout0_22 vdout0_22ck145 = 0 time = 1460
* CHECK dout0_23 vdout0_23ck145 = 3.3 time = 1460
* CHECK dout0_24 vdout0_24ck145 = 0 time = 1460
* CHECK dout0_25 vdout0_25ck145 = 3.3 time = 1460
* CHECK dout0_26 vdout0_26ck145 = 3.3 time = 1460
* CHECK dout0_27 vdout0_27ck145 = 0 time = 1460
* CHECK dout0_28 vdout0_28ck145 = 3.3 time = 1460
* CHECK dout0_29 vdout0_29ck145 = 0 time = 1460
* CHECK dout0_30 vdout0_30ck145 = 3.3 time = 1460
* CHECK dout0_31 vdout0_31ck145 = 0 time = 1460
* CHECK dout0_32 vdout0_32ck145 = 0 time = 1460
* CHECK dout0_0 vdout0_0ck147 = 0 time = 1480
* CHECK dout0_1 vdout0_1ck147 = 0 time = 1480
* CHECK dout0_2 vdout0_2ck147 = 0 time = 1480
* CHECK dout0_3 vdout0_3ck147 = 3.3 time = 1480
* CHECK dout0_4 vdout0_4ck147 = 0 time = 1480
* CHECK dout0_5 vdout0_5ck147 = 3.3 time = 1480
* CHECK dout0_6 vdout0_6ck147 = 0 time = 1480
* CHECK dout0_7 vdout0_7ck147 = 0 time = 1480
* CHECK dout0_8 vdout0_8ck147 = 3.3 time = 1480
* CHECK dout0_9 vdout0_9ck147 = 3.3 time = 1480
* CHECK dout0_10 vdout0_10ck147 = 3.3 time = 1480
* CHECK dout0_11 vdout0_11ck147 = 0 time = 1480
* CHECK dout0_12 vdout0_12ck147 = 0 time = 1480
* CHECK dout0_13 vdout0_13ck147 = 3.3 time = 1480
* CHECK dout0_14 vdout0_14ck147 = 3.3 time = 1480
* CHECK dout0_15 vdout0_15ck147 = 3.3 time = 1480
* CHECK dout0_16 vdout0_16ck147 = 0 time = 1480
* CHECK dout0_17 vdout0_17ck147 = 0 time = 1480
* CHECK dout0_18 vdout0_18ck147 = 3.3 time = 1480
* CHECK dout0_19 vdout0_19ck147 = 3.3 time = 1480
* CHECK dout0_20 vdout0_20ck147 = 0 time = 1480
* CHECK dout0_21 vdout0_21ck147 = 3.3 time = 1480
* CHECK dout0_22 vdout0_22ck147 = 3.3 time = 1480
* CHECK dout0_23 vdout0_23ck147 = 3.3 time = 1480
* CHECK dout0_24 vdout0_24ck147 = 0 time = 1480
* CHECK dout0_25 vdout0_25ck147 = 0 time = 1480
* CHECK dout0_26 vdout0_26ck147 = 3.3 time = 1480
* CHECK dout0_27 vdout0_27ck147 = 0 time = 1480
* CHECK dout0_28 vdout0_28ck147 = 0 time = 1480
* CHECK dout0_29 vdout0_29ck147 = 3.3 time = 1480
* CHECK dout0_30 vdout0_30ck147 = 0 time = 1480
* CHECK dout0_31 vdout0_31ck147 = 3.3 time = 1480
* CHECK dout0_32 vdout0_32ck147 = 0 time = 1480
* CHECK dout0_0 vdout0_0ck149 = 3.3 time = 1500
* CHECK dout0_1 vdout0_1ck149 = 0 time = 1500
* CHECK dout0_2 vdout0_2ck149 = 3.3 time = 1500
* CHECK dout0_3 vdout0_3ck149 = 0 time = 1500
* CHECK dout0_4 vdout0_4ck149 = 0 time = 1500
* CHECK dout0_5 vdout0_5ck149 = 0 time = 1500
* CHECK dout0_6 vdout0_6ck149 = 0 time = 1500
* CHECK dout0_7 vdout0_7ck149 = 3.3 time = 1500
* CHECK dout0_8 vdout0_8ck149 = 0 time = 1500
* CHECK dout0_9 vdout0_9ck149 = 0 time = 1500
* CHECK dout0_10 vdout0_10ck149 = 3.3 time = 1500
* CHECK dout0_11 vdout0_11ck149 = 0 time = 1500
* CHECK dout0_12 vdout0_12ck149 = 3.3 time = 1500
* CHECK dout0_13 vdout0_13ck149 = 3.3 time = 1500
* CHECK dout0_14 vdout0_14ck149 = 3.3 time = 1500
* CHECK dout0_15 vdout0_15ck149 = 3.3 time = 1500
* CHECK dout0_16 vdout0_16ck149 = 3.3 time = 1500
* CHECK dout0_17 vdout0_17ck149 = 3.3 time = 1500
* CHECK dout0_18 vdout0_18ck149 = 3.3 time = 1500
* CHECK dout0_19 vdout0_19ck149 = 0 time = 1500
* CHECK dout0_20 vdout0_20ck149 = 3.3 time = 1500
* CHECK dout0_21 vdout0_21ck149 = 3.3 time = 1500
* CHECK dout0_22 vdout0_22ck149 = 3.3 time = 1500
* CHECK dout0_23 vdout0_23ck149 = 3.3 time = 1500
* CHECK dout0_24 vdout0_24ck149 = 0 time = 1500
* CHECK dout0_25 vdout0_25ck149 = 3.3 time = 1500
* CHECK dout0_26 vdout0_26ck149 = 0 time = 1500
* CHECK dout0_27 vdout0_27ck149 = 0 time = 1500
* CHECK dout0_28 vdout0_28ck149 = 0 time = 1500
* CHECK dout0_29 vdout0_29ck149 = 0 time = 1500
* CHECK dout0_30 vdout0_30ck149 = 3.3 time = 1500
* CHECK dout0_31 vdout0_31ck149 = 0 time = 1500
* CHECK dout0_32 vdout0_32ck149 = 0 time = 1500
* CHECK dout0_0 vdout0_0ck150 = 3.3 time = 1510
* CHECK dout0_1 vdout0_1ck150 = 0 time = 1510
* CHECK dout0_2 vdout0_2ck150 = 3.3 time = 1510
* CHECK dout0_3 vdout0_3ck150 = 0 time = 1510
* CHECK dout0_4 vdout0_4ck150 = 0 time = 1510
* CHECK dout0_5 vdout0_5ck150 = 0 time = 1510
* CHECK dout0_6 vdout0_6ck150 = 0 time = 1510
* CHECK dout0_7 vdout0_7ck150 = 3.3 time = 1510
* CHECK dout0_8 vdout0_8ck150 = 0 time = 1510
* CHECK dout0_9 vdout0_9ck150 = 0 time = 1510
* CHECK dout0_10 vdout0_10ck150 = 3.3 time = 1510
* CHECK dout0_11 vdout0_11ck150 = 0 time = 1510
* CHECK dout0_12 vdout0_12ck150 = 3.3 time = 1510
* CHECK dout0_13 vdout0_13ck150 = 3.3 time = 1510
* CHECK dout0_14 vdout0_14ck150 = 3.3 time = 1510
* CHECK dout0_15 vdout0_15ck150 = 3.3 time = 1510
* CHECK dout0_16 vdout0_16ck150 = 3.3 time = 1510
* CHECK dout0_17 vdout0_17ck150 = 3.3 time = 1510
* CHECK dout0_18 vdout0_18ck150 = 3.3 time = 1510
* CHECK dout0_19 vdout0_19ck150 = 0 time = 1510
* CHECK dout0_20 vdout0_20ck150 = 3.3 time = 1510
* CHECK dout0_21 vdout0_21ck150 = 3.3 time = 1510
* CHECK dout0_22 vdout0_22ck150 = 3.3 time = 1510
* CHECK dout0_23 vdout0_23ck150 = 3.3 time = 1510
* CHECK dout0_24 vdout0_24ck150 = 0 time = 1510
* CHECK dout0_25 vdout0_25ck150 = 3.3 time = 1510
* CHECK dout0_26 vdout0_26ck150 = 0 time = 1510
* CHECK dout0_27 vdout0_27ck150 = 0 time = 1510
* CHECK dout0_28 vdout0_28ck150 = 0 time = 1510
* CHECK dout0_29 vdout0_29ck150 = 0 time = 1510
* CHECK dout0_30 vdout0_30ck150 = 3.3 time = 1510
* CHECK dout0_31 vdout0_31ck150 = 0 time = 1510
* CHECK dout0_32 vdout0_32ck150 = 0 time = 1510
* CHECK dout0_0 vdout0_0ck151 = 0 time = 1520
* CHECK dout0_1 vdout0_1ck151 = 0 time = 1520
* CHECK dout0_2 vdout0_2ck151 = 0 time = 1520
* CHECK dout0_3 vdout0_3ck151 = 3.3 time = 1520
* CHECK dout0_4 vdout0_4ck151 = 0 time = 1520
* CHECK dout0_5 vdout0_5ck151 = 3.3 time = 1520
* CHECK dout0_6 vdout0_6ck151 = 0 time = 1520
* CHECK dout0_7 vdout0_7ck151 = 0 time = 1520
* CHECK dout0_8 vdout0_8ck151 = 3.3 time = 1520
* CHECK dout0_9 vdout0_9ck151 = 3.3 time = 1520
* CHECK dout0_10 vdout0_10ck151 = 3.3 time = 1520
* CHECK dout0_11 vdout0_11ck151 = 0 time = 1520
* CHECK dout0_12 vdout0_12ck151 = 0 time = 1520
* CHECK dout0_13 vdout0_13ck151 = 3.3 time = 1520
* CHECK dout0_14 vdout0_14ck151 = 3.3 time = 1520
* CHECK dout0_15 vdout0_15ck151 = 3.3 time = 1520
* CHECK dout0_16 vdout0_16ck151 = 0 time = 1520
* CHECK dout0_17 vdout0_17ck151 = 0 time = 1520
* CHECK dout0_18 vdout0_18ck151 = 3.3 time = 1520
* CHECK dout0_19 vdout0_19ck151 = 3.3 time = 1520
* CHECK dout0_20 vdout0_20ck151 = 0 time = 1520
* CHECK dout0_21 vdout0_21ck151 = 3.3 time = 1520
* CHECK dout0_22 vdout0_22ck151 = 3.3 time = 1520
* CHECK dout0_23 vdout0_23ck151 = 3.3 time = 1520
* CHECK dout0_24 vdout0_24ck151 = 0 time = 1520
* CHECK dout0_25 vdout0_25ck151 = 0 time = 1520
* CHECK dout0_26 vdout0_26ck151 = 3.3 time = 1520
* CHECK dout0_27 vdout0_27ck151 = 0 time = 1520
* CHECK dout0_28 vdout0_28ck151 = 0 time = 1520
* CHECK dout0_29 vdout0_29ck151 = 3.3 time = 1520
* CHECK dout0_30 vdout0_30ck151 = 0 time = 1520
* CHECK dout0_31 vdout0_31ck151 = 3.3 time = 1520
* CHECK dout0_32 vdout0_32ck151 = 0 time = 1520
* CHECK dout0_0 vdout0_0ck152 = 0 time = 1530
* CHECK dout0_1 vdout0_1ck152 = 0 time = 1530
* CHECK dout0_2 vdout0_2ck152 = 0 time = 1530
* CHECK dout0_3 vdout0_3ck152 = 3.3 time = 1530
* CHECK dout0_4 vdout0_4ck152 = 0 time = 1530
* CHECK dout0_5 vdout0_5ck152 = 3.3 time = 1530
* CHECK dout0_6 vdout0_6ck152 = 0 time = 1530
* CHECK dout0_7 vdout0_7ck152 = 0 time = 1530
* CHECK dout0_8 vdout0_8ck152 = 3.3 time = 1530
* CHECK dout0_9 vdout0_9ck152 = 3.3 time = 1530
* CHECK dout0_10 vdout0_10ck152 = 3.3 time = 1530
* CHECK dout0_11 vdout0_11ck152 = 0 time = 1530
* CHECK dout0_12 vdout0_12ck152 = 0 time = 1530
* CHECK dout0_13 vdout0_13ck152 = 3.3 time = 1530
* CHECK dout0_14 vdout0_14ck152 = 3.3 time = 1530
* CHECK dout0_15 vdout0_15ck152 = 3.3 time = 1530
* CHECK dout0_16 vdout0_16ck152 = 0 time = 1530
* CHECK dout0_17 vdout0_17ck152 = 0 time = 1530
* CHECK dout0_18 vdout0_18ck152 = 3.3 time = 1530
* CHECK dout0_19 vdout0_19ck152 = 3.3 time = 1530
* CHECK dout0_20 vdout0_20ck152 = 0 time = 1530
* CHECK dout0_21 vdout0_21ck152 = 3.3 time = 1530
* CHECK dout0_22 vdout0_22ck152 = 3.3 time = 1530
* CHECK dout0_23 vdout0_23ck152 = 3.3 time = 1530
* CHECK dout0_24 vdout0_24ck152 = 0 time = 1530
* CHECK dout0_25 vdout0_25ck152 = 0 time = 1530
* CHECK dout0_26 vdout0_26ck152 = 3.3 time = 1530
* CHECK dout0_27 vdout0_27ck152 = 0 time = 1530
* CHECK dout0_28 vdout0_28ck152 = 0 time = 1530
* CHECK dout0_29 vdout0_29ck152 = 3.3 time = 1530
* CHECK dout0_30 vdout0_30ck152 = 0 time = 1530
* CHECK dout0_31 vdout0_31ck152 = 3.3 time = 1530
* CHECK dout0_32 vdout0_32ck152 = 0 time = 1530
* CHECK dout0_0 vdout0_0ck154 = 3.3 time = 1550
* CHECK dout0_1 vdout0_1ck154 = 0 time = 1550
* CHECK dout0_2 vdout0_2ck154 = 3.3 time = 1550
* CHECK dout0_3 vdout0_3ck154 = 0 time = 1550
* CHECK dout0_4 vdout0_4ck154 = 0 time = 1550
* CHECK dout0_5 vdout0_5ck154 = 0 time = 1550
* CHECK dout0_6 vdout0_6ck154 = 0 time = 1550
* CHECK dout0_7 vdout0_7ck154 = 3.3 time = 1550
* CHECK dout0_8 vdout0_8ck154 = 0 time = 1550
* CHECK dout0_9 vdout0_9ck154 = 0 time = 1550
* CHECK dout0_10 vdout0_10ck154 = 3.3 time = 1550
* CHECK dout0_11 vdout0_11ck154 = 0 time = 1550
* CHECK dout0_12 vdout0_12ck154 = 3.3 time = 1550
* CHECK dout0_13 vdout0_13ck154 = 3.3 time = 1550
* CHECK dout0_14 vdout0_14ck154 = 3.3 time = 1550
* CHECK dout0_15 vdout0_15ck154 = 3.3 time = 1550
* CHECK dout0_16 vdout0_16ck154 = 3.3 time = 1550
* CHECK dout0_17 vdout0_17ck154 = 3.3 time = 1550
* CHECK dout0_18 vdout0_18ck154 = 3.3 time = 1550
* CHECK dout0_19 vdout0_19ck154 = 0 time = 1550
* CHECK dout0_20 vdout0_20ck154 = 3.3 time = 1550
* CHECK dout0_21 vdout0_21ck154 = 3.3 time = 1550
* CHECK dout0_22 vdout0_22ck154 = 3.3 time = 1550
* CHECK dout0_23 vdout0_23ck154 = 3.3 time = 1550
* CHECK dout0_24 vdout0_24ck154 = 0 time = 1550
* CHECK dout0_25 vdout0_25ck154 = 3.3 time = 1550
* CHECK dout0_26 vdout0_26ck154 = 0 time = 1550
* CHECK dout0_27 vdout0_27ck154 = 0 time = 1550
* CHECK dout0_28 vdout0_28ck154 = 0 time = 1550
* CHECK dout0_29 vdout0_29ck154 = 0 time = 1550
* CHECK dout0_30 vdout0_30ck154 = 3.3 time = 1550
* CHECK dout0_31 vdout0_31ck154 = 0 time = 1550
* CHECK dout0_32 vdout0_32ck154 = 0 time = 1550
* CHECK dout0_0 vdout0_0ck155 = 0 time = 1560
* CHECK dout0_1 vdout0_1ck155 = 0 time = 1560
* CHECK dout0_2 vdout0_2ck155 = 0 time = 1560
* CHECK dout0_3 vdout0_3ck155 = 3.3 time = 1560
* CHECK dout0_4 vdout0_4ck155 = 0 time = 1560
* CHECK dout0_5 vdout0_5ck155 = 3.3 time = 1560
* CHECK dout0_6 vdout0_6ck155 = 0 time = 1560
* CHECK dout0_7 vdout0_7ck155 = 0 time = 1560
* CHECK dout0_8 vdout0_8ck155 = 3.3 time = 1560
* CHECK dout0_9 vdout0_9ck155 = 3.3 time = 1560
* CHECK dout0_10 vdout0_10ck155 = 3.3 time = 1560
* CHECK dout0_11 vdout0_11ck155 = 0 time = 1560
* CHECK dout0_12 vdout0_12ck155 = 0 time = 1560
* CHECK dout0_13 vdout0_13ck155 = 3.3 time = 1560
* CHECK dout0_14 vdout0_14ck155 = 3.3 time = 1560
* CHECK dout0_15 vdout0_15ck155 = 3.3 time = 1560
* CHECK dout0_16 vdout0_16ck155 = 0 time = 1560
* CHECK dout0_17 vdout0_17ck155 = 0 time = 1560
* CHECK dout0_18 vdout0_18ck155 = 3.3 time = 1560
* CHECK dout0_19 vdout0_19ck155 = 3.3 time = 1560
* CHECK dout0_20 vdout0_20ck155 = 0 time = 1560
* CHECK dout0_21 vdout0_21ck155 = 3.3 time = 1560
* CHECK dout0_22 vdout0_22ck155 = 3.3 time = 1560
* CHECK dout0_23 vdout0_23ck155 = 3.3 time = 1560
* CHECK dout0_24 vdout0_24ck155 = 0 time = 1560
* CHECK dout0_25 vdout0_25ck155 = 0 time = 1560
* CHECK dout0_26 vdout0_26ck155 = 3.3 time = 1560
* CHECK dout0_27 vdout0_27ck155 = 0 time = 1560
* CHECK dout0_28 vdout0_28ck155 = 0 time = 1560
* CHECK dout0_29 vdout0_29ck155 = 3.3 time = 1560
* CHECK dout0_30 vdout0_30ck155 = 0 time = 1560
* CHECK dout0_31 vdout0_31ck155 = 3.3 time = 1560
* CHECK dout0_32 vdout0_32ck155 = 0 time = 1560
* CHECK dout0_0 vdout0_0ck157 = 3.3 time = 1580
* CHECK dout0_1 vdout0_1ck157 = 0 time = 1580
* CHECK dout0_2 vdout0_2ck157 = 3.3 time = 1580
* CHECK dout0_3 vdout0_3ck157 = 0 time = 1580
* CHECK dout0_4 vdout0_4ck157 = 0 time = 1580
* CHECK dout0_5 vdout0_5ck157 = 0 time = 1580
* CHECK dout0_6 vdout0_6ck157 = 0 time = 1580
* CHECK dout0_7 vdout0_7ck157 = 3.3 time = 1580
* CHECK dout0_8 vdout0_8ck157 = 0 time = 1580
* CHECK dout0_9 vdout0_9ck157 = 0 time = 1580
* CHECK dout0_10 vdout0_10ck157 = 3.3 time = 1580
* CHECK dout0_11 vdout0_11ck157 = 0 time = 1580
* CHECK dout0_12 vdout0_12ck157 = 3.3 time = 1580
* CHECK dout0_13 vdout0_13ck157 = 3.3 time = 1580
* CHECK dout0_14 vdout0_14ck157 = 3.3 time = 1580
* CHECK dout0_15 vdout0_15ck157 = 3.3 time = 1580
* CHECK dout0_16 vdout0_16ck157 = 3.3 time = 1580
* CHECK dout0_17 vdout0_17ck157 = 3.3 time = 1580
* CHECK dout0_18 vdout0_18ck157 = 3.3 time = 1580
* CHECK dout0_19 vdout0_19ck157 = 0 time = 1580
* CHECK dout0_20 vdout0_20ck157 = 3.3 time = 1580
* CHECK dout0_21 vdout0_21ck157 = 3.3 time = 1580
* CHECK dout0_22 vdout0_22ck157 = 3.3 time = 1580
* CHECK dout0_23 vdout0_23ck157 = 3.3 time = 1580
* CHECK dout0_24 vdout0_24ck157 = 0 time = 1580
* CHECK dout0_25 vdout0_25ck157 = 3.3 time = 1580
* CHECK dout0_26 vdout0_26ck157 = 0 time = 1580
* CHECK dout0_27 vdout0_27ck157 = 0 time = 1580
* CHECK dout0_28 vdout0_28ck157 = 0 time = 1580
* CHECK dout0_29 vdout0_29ck157 = 0 time = 1580
* CHECK dout0_30 vdout0_30ck157 = 3.3 time = 1580
* CHECK dout0_31 vdout0_31ck157 = 0 time = 1580
* CHECK dout0_32 vdout0_32ck157 = 0 time = 1580
* CHECK dout0_0 vdout0_0ck158 = 0 time = 1590
* CHECK dout0_1 vdout0_1ck158 = 0 time = 1590
* CHECK dout0_2 vdout0_2ck158 = 0 time = 1590
* CHECK dout0_3 vdout0_3ck158 = 3.3 time = 1590
* CHECK dout0_4 vdout0_4ck158 = 0 time = 1590
* CHECK dout0_5 vdout0_5ck158 = 3.3 time = 1590
* CHECK dout0_6 vdout0_6ck158 = 0 time = 1590
* CHECK dout0_7 vdout0_7ck158 = 0 time = 1590
* CHECK dout0_8 vdout0_8ck158 = 3.3 time = 1590
* CHECK dout0_9 vdout0_9ck158 = 3.3 time = 1590
* CHECK dout0_10 vdout0_10ck158 = 3.3 time = 1590
* CHECK dout0_11 vdout0_11ck158 = 0 time = 1590
* CHECK dout0_12 vdout0_12ck158 = 0 time = 1590
* CHECK dout0_13 vdout0_13ck158 = 3.3 time = 1590
* CHECK dout0_14 vdout0_14ck158 = 3.3 time = 1590
* CHECK dout0_15 vdout0_15ck158 = 3.3 time = 1590
* CHECK dout0_16 vdout0_16ck158 = 0 time = 1590
* CHECK dout0_17 vdout0_17ck158 = 0 time = 1590
* CHECK dout0_18 vdout0_18ck158 = 3.3 time = 1590
* CHECK dout0_19 vdout0_19ck158 = 3.3 time = 1590
* CHECK dout0_20 vdout0_20ck158 = 0 time = 1590
* CHECK dout0_21 vdout0_21ck158 = 3.3 time = 1590
* CHECK dout0_22 vdout0_22ck158 = 3.3 time = 1590
* CHECK dout0_23 vdout0_23ck158 = 3.3 time = 1590
* CHECK dout0_24 vdout0_24ck158 = 0 time = 1590
* CHECK dout0_25 vdout0_25ck158 = 0 time = 1590
* CHECK dout0_26 vdout0_26ck158 = 3.3 time = 1590
* CHECK dout0_27 vdout0_27ck158 = 0 time = 1590
* CHECK dout0_28 vdout0_28ck158 = 0 time = 1590
* CHECK dout0_29 vdout0_29ck158 = 3.3 time = 1590
* CHECK dout0_30 vdout0_30ck158 = 0 time = 1590
* CHECK dout0_31 vdout0_31ck158 = 3.3 time = 1590
* CHECK dout0_32 vdout0_32ck158 = 0 time = 1590
* CHECK dout0_0 vdout0_0ck160 = 0 time = 1610
* CHECK dout0_1 vdout0_1ck160 = 0 time = 1610
* CHECK dout0_2 vdout0_2ck160 = 0 time = 1610
* CHECK dout0_3 vdout0_3ck160 = 3.3 time = 1610
* CHECK dout0_4 vdout0_4ck160 = 0 time = 1610
* CHECK dout0_5 vdout0_5ck160 = 3.3 time = 1610
* CHECK dout0_6 vdout0_6ck160 = 0 time = 1610
* CHECK dout0_7 vdout0_7ck160 = 0 time = 1610
* CHECK dout0_8 vdout0_8ck160 = 3.3 time = 1610
* CHECK dout0_9 vdout0_9ck160 = 3.3 time = 1610
* CHECK dout0_10 vdout0_10ck160 = 3.3 time = 1610
* CHECK dout0_11 vdout0_11ck160 = 0 time = 1610
* CHECK dout0_12 vdout0_12ck160 = 0 time = 1610
* CHECK dout0_13 vdout0_13ck160 = 3.3 time = 1610
* CHECK dout0_14 vdout0_14ck160 = 3.3 time = 1610
* CHECK dout0_15 vdout0_15ck160 = 3.3 time = 1610
* CHECK dout0_16 vdout0_16ck160 = 0 time = 1610
* CHECK dout0_17 vdout0_17ck160 = 0 time = 1610
* CHECK dout0_18 vdout0_18ck160 = 3.3 time = 1610
* CHECK dout0_19 vdout0_19ck160 = 3.3 time = 1610
* CHECK dout0_20 vdout0_20ck160 = 0 time = 1610
* CHECK dout0_21 vdout0_21ck160 = 3.3 time = 1610
* CHECK dout0_22 vdout0_22ck160 = 3.3 time = 1610
* CHECK dout0_23 vdout0_23ck160 = 3.3 time = 1610
* CHECK dout0_24 vdout0_24ck160 = 0 time = 1610
* CHECK dout0_25 vdout0_25ck160 = 0 time = 1610
* CHECK dout0_26 vdout0_26ck160 = 3.3 time = 1610
* CHECK dout0_27 vdout0_27ck160 = 0 time = 1610
* CHECK dout0_28 vdout0_28ck160 = 0 time = 1610
* CHECK dout0_29 vdout0_29ck160 = 3.3 time = 1610
* CHECK dout0_30 vdout0_30ck160 = 0 time = 1610
* CHECK dout0_31 vdout0_31ck160 = 3.3 time = 1610
* CHECK dout0_32 vdout0_32ck160 = 0 time = 1610
* CHECK dout0_0 vdout0_0ck166 = 0 time = 1670
* CHECK dout0_1 vdout0_1ck166 = 0 time = 1670
* CHECK dout0_2 vdout0_2ck166 = 0 time = 1670
* CHECK dout0_3 vdout0_3ck166 = 3.3 time = 1670
* CHECK dout0_4 vdout0_4ck166 = 0 time = 1670
* CHECK dout0_5 vdout0_5ck166 = 3.3 time = 1670
* CHECK dout0_6 vdout0_6ck166 = 0 time = 1670
* CHECK dout0_7 vdout0_7ck166 = 0 time = 1670
* CHECK dout0_8 vdout0_8ck166 = 3.3 time = 1670
* CHECK dout0_9 vdout0_9ck166 = 3.3 time = 1670
* CHECK dout0_10 vdout0_10ck166 = 3.3 time = 1670
* CHECK dout0_11 vdout0_11ck166 = 0 time = 1670
* CHECK dout0_12 vdout0_12ck166 = 0 time = 1670
* CHECK dout0_13 vdout0_13ck166 = 3.3 time = 1670
* CHECK dout0_14 vdout0_14ck166 = 3.3 time = 1670
* CHECK dout0_15 vdout0_15ck166 = 3.3 time = 1670
* CHECK dout0_16 vdout0_16ck166 = 0 time = 1670
* CHECK dout0_17 vdout0_17ck166 = 0 time = 1670
* CHECK dout0_18 vdout0_18ck166 = 3.3 time = 1670
* CHECK dout0_19 vdout0_19ck166 = 3.3 time = 1670
* CHECK dout0_20 vdout0_20ck166 = 0 time = 1670
* CHECK dout0_21 vdout0_21ck166 = 3.3 time = 1670
* CHECK dout0_22 vdout0_22ck166 = 3.3 time = 1670
* CHECK dout0_23 vdout0_23ck166 = 3.3 time = 1670
* CHECK dout0_24 vdout0_24ck166 = 0 time = 1670
* CHECK dout0_25 vdout0_25ck166 = 0 time = 1670
* CHECK dout0_26 vdout0_26ck166 = 3.3 time = 1670
* CHECK dout0_27 vdout0_27ck166 = 0 time = 1670
* CHECK dout0_28 vdout0_28ck166 = 0 time = 1670
* CHECK dout0_29 vdout0_29ck166 = 3.3 time = 1670
* CHECK dout0_30 vdout0_30ck166 = 0 time = 1670
* CHECK dout0_31 vdout0_31ck166 = 3.3 time = 1670
* CHECK dout0_32 vdout0_32ck166 = 0 time = 1670
* CHECK dout0_0 vdout0_0ck167 = 0 time = 1680
* CHECK dout0_1 vdout0_1ck167 = 0 time = 1680
* CHECK dout0_2 vdout0_2ck167 = 0 time = 1680
* CHECK dout0_3 vdout0_3ck167 = 3.3 time = 1680
* CHECK dout0_4 vdout0_4ck167 = 0 time = 1680
* CHECK dout0_5 vdout0_5ck167 = 3.3 time = 1680
* CHECK dout0_6 vdout0_6ck167 = 0 time = 1680
* CHECK dout0_7 vdout0_7ck167 = 0 time = 1680
* CHECK dout0_8 vdout0_8ck167 = 3.3 time = 1680
* CHECK dout0_9 vdout0_9ck167 = 3.3 time = 1680
* CHECK dout0_10 vdout0_10ck167 = 3.3 time = 1680
* CHECK dout0_11 vdout0_11ck167 = 0 time = 1680
* CHECK dout0_12 vdout0_12ck167 = 0 time = 1680
* CHECK dout0_13 vdout0_13ck167 = 3.3 time = 1680
* CHECK dout0_14 vdout0_14ck167 = 3.3 time = 1680
* CHECK dout0_15 vdout0_15ck167 = 3.3 time = 1680
* CHECK dout0_16 vdout0_16ck167 = 0 time = 1680
* CHECK dout0_17 vdout0_17ck167 = 0 time = 1680
* CHECK dout0_18 vdout0_18ck167 = 3.3 time = 1680
* CHECK dout0_19 vdout0_19ck167 = 3.3 time = 1680
* CHECK dout0_20 vdout0_20ck167 = 0 time = 1680
* CHECK dout0_21 vdout0_21ck167 = 3.3 time = 1680
* CHECK dout0_22 vdout0_22ck167 = 3.3 time = 1680
* CHECK dout0_23 vdout0_23ck167 = 3.3 time = 1680
* CHECK dout0_24 vdout0_24ck167 = 0 time = 1680
* CHECK dout0_25 vdout0_25ck167 = 0 time = 1680
* CHECK dout0_26 vdout0_26ck167 = 3.3 time = 1680
* CHECK dout0_27 vdout0_27ck167 = 0 time = 1680
* CHECK dout0_28 vdout0_28ck167 = 0 time = 1680
* CHECK dout0_29 vdout0_29ck167 = 3.3 time = 1680
* CHECK dout0_30 vdout0_30ck167 = 0 time = 1680
* CHECK dout0_31 vdout0_31ck167 = 3.3 time = 1680
* CHECK dout0_32 vdout0_32ck167 = 0 time = 1680
* CHECK dout0_0 vdout0_0ck168 = 0 time = 1690
* CHECK dout0_1 vdout0_1ck168 = 0 time = 1690
* CHECK dout0_2 vdout0_2ck168 = 0 time = 1690
* CHECK dout0_3 vdout0_3ck168 = 3.3 time = 1690
* CHECK dout0_4 vdout0_4ck168 = 0 time = 1690
* CHECK dout0_5 vdout0_5ck168 = 3.3 time = 1690
* CHECK dout0_6 vdout0_6ck168 = 0 time = 1690
* CHECK dout0_7 vdout0_7ck168 = 0 time = 1690
* CHECK dout0_8 vdout0_8ck168 = 3.3 time = 1690
* CHECK dout0_9 vdout0_9ck168 = 3.3 time = 1690
* CHECK dout0_10 vdout0_10ck168 = 3.3 time = 1690
* CHECK dout0_11 vdout0_11ck168 = 0 time = 1690
* CHECK dout0_12 vdout0_12ck168 = 0 time = 1690
* CHECK dout0_13 vdout0_13ck168 = 3.3 time = 1690
* CHECK dout0_14 vdout0_14ck168 = 3.3 time = 1690
* CHECK dout0_15 vdout0_15ck168 = 3.3 time = 1690
* CHECK dout0_16 vdout0_16ck168 = 0 time = 1690
* CHECK dout0_17 vdout0_17ck168 = 0 time = 1690
* CHECK dout0_18 vdout0_18ck168 = 3.3 time = 1690
* CHECK dout0_19 vdout0_19ck168 = 3.3 time = 1690
* CHECK dout0_20 vdout0_20ck168 = 0 time = 1690
* CHECK dout0_21 vdout0_21ck168 = 3.3 time = 1690
* CHECK dout0_22 vdout0_22ck168 = 3.3 time = 1690
* CHECK dout0_23 vdout0_23ck168 = 3.3 time = 1690
* CHECK dout0_24 vdout0_24ck168 = 0 time = 1690
* CHECK dout0_25 vdout0_25ck168 = 0 time = 1690
* CHECK dout0_26 vdout0_26ck168 = 3.3 time = 1690
* CHECK dout0_27 vdout0_27ck168 = 0 time = 1690
* CHECK dout0_28 vdout0_28ck168 = 0 time = 1690
* CHECK dout0_29 vdout0_29ck168 = 3.3 time = 1690
* CHECK dout0_30 vdout0_30ck168 = 0 time = 1690
* CHECK dout0_31 vdout0_31ck168 = 3.3 time = 1690
* CHECK dout0_32 vdout0_32ck168 = 0 time = 1690
* CHECK dout0_0 vdout0_0ck169 = 3.3 time = 1700
* CHECK dout0_1 vdout0_1ck169 = 0 time = 1700
* CHECK dout0_2 vdout0_2ck169 = 3.3 time = 1700
* CHECK dout0_3 vdout0_3ck169 = 0 time = 1700
* CHECK dout0_4 vdout0_4ck169 = 0 time = 1700
* CHECK dout0_5 vdout0_5ck169 = 3.3 time = 1700
* CHECK dout0_6 vdout0_6ck169 = 3.3 time = 1700
* CHECK dout0_7 vdout0_7ck169 = 0 time = 1700
* CHECK dout0_8 vdout0_8ck169 = 3.3 time = 1700
* CHECK dout0_9 vdout0_9ck169 = 3.3 time = 1700
* CHECK dout0_10 vdout0_10ck169 = 0 time = 1700
* CHECK dout0_11 vdout0_11ck169 = 3.3 time = 1700
* CHECK dout0_12 vdout0_12ck169 = 0 time = 1700
* CHECK dout0_13 vdout0_13ck169 = 3.3 time = 1700
* CHECK dout0_14 vdout0_14ck169 = 3.3 time = 1700
* CHECK dout0_15 vdout0_15ck169 = 3.3 time = 1700
* CHECK dout0_16 vdout0_16ck169 = 3.3 time = 1700
* CHECK dout0_17 vdout0_17ck169 = 0 time = 1700
* CHECK dout0_18 vdout0_18ck169 = 3.3 time = 1700
* CHECK dout0_19 vdout0_19ck169 = 0 time = 1700
* CHECK dout0_20 vdout0_20ck169 = 3.3 time = 1700
* CHECK dout0_21 vdout0_21ck169 = 3.3 time = 1700
* CHECK dout0_22 vdout0_22ck169 = 3.3 time = 1700
* CHECK dout0_23 vdout0_23ck169 = 0 time = 1700
* CHECK dout0_24 vdout0_24ck169 = 3.3 time = 1700
* CHECK dout0_25 vdout0_25ck169 = 0 time = 1700
* CHECK dout0_26 vdout0_26ck169 = 0 time = 1700
* CHECK dout0_27 vdout0_27ck169 = 0 time = 1700
* CHECK dout0_28 vdout0_28ck169 = 3.3 time = 1700
* CHECK dout0_29 vdout0_29ck169 = 3.3 time = 1700
* CHECK dout0_30 vdout0_30ck169 = 0 time = 1700
* CHECK dout0_31 vdout0_31ck169 = 3.3 time = 1700
* CHECK dout0_32 vdout0_32ck169 = 0 time = 1700
* CHECK dout0_0 vdout0_0ck170 = 0 time = 1710
* CHECK dout0_1 vdout0_1ck170 = 0 time = 1710
* CHECK dout0_2 vdout0_2ck170 = 0 time = 1710
* CHECK dout0_3 vdout0_3ck170 = 3.3 time = 1710
* CHECK dout0_4 vdout0_4ck170 = 0 time = 1710
* CHECK dout0_5 vdout0_5ck170 = 3.3 time = 1710
* CHECK dout0_6 vdout0_6ck170 = 0 time = 1710
* CHECK dout0_7 vdout0_7ck170 = 0 time = 1710
* CHECK dout0_8 vdout0_8ck170 = 3.3 time = 1710
* CHECK dout0_9 vdout0_9ck170 = 3.3 time = 1710
* CHECK dout0_10 vdout0_10ck170 = 3.3 time = 1710
* CHECK dout0_11 vdout0_11ck170 = 0 time = 1710
* CHECK dout0_12 vdout0_12ck170 = 0 time = 1710
* CHECK dout0_13 vdout0_13ck170 = 3.3 time = 1710
* CHECK dout0_14 vdout0_14ck170 = 3.3 time = 1710
* CHECK dout0_15 vdout0_15ck170 = 3.3 time = 1710
* CHECK dout0_16 vdout0_16ck170 = 0 time = 1710
* CHECK dout0_17 vdout0_17ck170 = 0 time = 1710
* CHECK dout0_18 vdout0_18ck170 = 3.3 time = 1710
* CHECK dout0_19 vdout0_19ck170 = 3.3 time = 1710
* CHECK dout0_20 vdout0_20ck170 = 0 time = 1710
* CHECK dout0_21 vdout0_21ck170 = 3.3 time = 1710
* CHECK dout0_22 vdout0_22ck170 = 3.3 time = 1710
* CHECK dout0_23 vdout0_23ck170 = 3.3 time = 1710
* CHECK dout0_24 vdout0_24ck170 = 0 time = 1710
* CHECK dout0_25 vdout0_25ck170 = 0 time = 1710
* CHECK dout0_26 vdout0_26ck170 = 3.3 time = 1710
* CHECK dout0_27 vdout0_27ck170 = 0 time = 1710
* CHECK dout0_28 vdout0_28ck170 = 0 time = 1710
* CHECK dout0_29 vdout0_29ck170 = 3.3 time = 1710
* CHECK dout0_30 vdout0_30ck170 = 0 time = 1710
* CHECK dout0_31 vdout0_31ck170 = 3.3 time = 1710
* CHECK dout0_32 vdout0_32ck170 = 0 time = 1710
* CHECK dout0_0 vdout0_0ck174 = 3.3 time = 1750
* CHECK dout0_1 vdout0_1ck174 = 0 time = 1750
* CHECK dout0_2 vdout0_2ck174 = 0 time = 1750
* CHECK dout0_3 vdout0_3ck174 = 0 time = 1750
* CHECK dout0_4 vdout0_4ck174 = 3.3 time = 1750
* CHECK dout0_5 vdout0_5ck174 = 3.3 time = 1750
* CHECK dout0_6 vdout0_6ck174 = 3.3 time = 1750
* CHECK dout0_7 vdout0_7ck174 = 0 time = 1750
* CHECK dout0_8 vdout0_8ck174 = 0 time = 1750
* CHECK dout0_9 vdout0_9ck174 = 0 time = 1750
* CHECK dout0_10 vdout0_10ck174 = 3.3 time = 1750
* CHECK dout0_11 vdout0_11ck174 = 3.3 time = 1750
* CHECK dout0_12 vdout0_12ck174 = 0 time = 1750
* CHECK dout0_13 vdout0_13ck174 = 0 time = 1750
* CHECK dout0_14 vdout0_14ck174 = 3.3 time = 1750
* CHECK dout0_15 vdout0_15ck174 = 3.3 time = 1750
* CHECK dout0_16 vdout0_16ck174 = 3.3 time = 1750
* CHECK dout0_17 vdout0_17ck174 = 0 time = 1750
* CHECK dout0_18 vdout0_18ck174 = 3.3 time = 1750
* CHECK dout0_19 vdout0_19ck174 = 3.3 time = 1750
* CHECK dout0_20 vdout0_20ck174 = 0 time = 1750
* CHECK dout0_21 vdout0_21ck174 = 0 time = 1750
* CHECK dout0_22 vdout0_22ck174 = 3.3 time = 1750
* CHECK dout0_23 vdout0_23ck174 = 3.3 time = 1750
* CHECK dout0_24 vdout0_24ck174 = 3.3 time = 1750
* CHECK dout0_25 vdout0_25ck174 = 0 time = 1750
* CHECK dout0_26 vdout0_26ck174 = 0 time = 1750
* CHECK dout0_27 vdout0_27ck174 = 0 time = 1750
* CHECK dout0_28 vdout0_28ck174 = 3.3 time = 1750
* CHECK dout0_29 vdout0_29ck174 = 0 time = 1750
* CHECK dout0_30 vdout0_30ck174 = 0 time = 1750
* CHECK dout0_31 vdout0_31ck174 = 3.3 time = 1750
* CHECK dout0_32 vdout0_32ck174 = 0 time = 1750
* CHECK dout0_0 vdout0_0ck177 = 3.3 time = 1780
* CHECK dout0_1 vdout0_1ck177 = 0 time = 1780
* CHECK dout0_2 vdout0_2ck177 = 0 time = 1780
* CHECK dout0_3 vdout0_3ck177 = 0 time = 1780
* CHECK dout0_4 vdout0_4ck177 = 3.3 time = 1780
* CHECK dout0_5 vdout0_5ck177 = 3.3 time = 1780
* CHECK dout0_6 vdout0_6ck177 = 3.3 time = 1780
* CHECK dout0_7 vdout0_7ck177 = 0 time = 1780
* CHECK dout0_8 vdout0_8ck177 = 0 time = 1780
* CHECK dout0_9 vdout0_9ck177 = 0 time = 1780
* CHECK dout0_10 vdout0_10ck177 = 3.3 time = 1780
* CHECK dout0_11 vdout0_11ck177 = 3.3 time = 1780
* CHECK dout0_12 vdout0_12ck177 = 0 time = 1780
* CHECK dout0_13 vdout0_13ck177 = 0 time = 1780
* CHECK dout0_14 vdout0_14ck177 = 3.3 time = 1780
* CHECK dout0_15 vdout0_15ck177 = 3.3 time = 1780
* CHECK dout0_16 vdout0_16ck177 = 3.3 time = 1780
* CHECK dout0_17 vdout0_17ck177 = 0 time = 1780
* CHECK dout0_18 vdout0_18ck177 = 3.3 time = 1780
* CHECK dout0_19 vdout0_19ck177 = 3.3 time = 1780
* CHECK dout0_20 vdout0_20ck177 = 0 time = 1780
* CHECK dout0_21 vdout0_21ck177 = 0 time = 1780
* CHECK dout0_22 vdout0_22ck177 = 3.3 time = 1780
* CHECK dout0_23 vdout0_23ck177 = 3.3 time = 1780
* CHECK dout0_24 vdout0_24ck177 = 3.3 time = 1780
* CHECK dout0_25 vdout0_25ck177 = 0 time = 1780
* CHECK dout0_26 vdout0_26ck177 = 0 time = 1780
* CHECK dout0_27 vdout0_27ck177 = 0 time = 1780
* CHECK dout0_28 vdout0_28ck177 = 3.3 time = 1780
* CHECK dout0_29 vdout0_29ck177 = 0 time = 1780
* CHECK dout0_30 vdout0_30ck177 = 0 time = 1780
* CHECK dout0_31 vdout0_31ck177 = 3.3 time = 1780
* CHECK dout0_32 vdout0_32ck177 = 0 time = 1780
* CHECK dout0_0 vdout0_0ck179 = 3.3 time = 1800
* CHECK dout0_1 vdout0_1ck179 = 0 time = 1800
* CHECK dout0_2 vdout0_2ck179 = 3.3 time = 1800
* CHECK dout0_3 vdout0_3ck179 = 0 time = 1800
* CHECK dout0_4 vdout0_4ck179 = 0 time = 1800
* CHECK dout0_5 vdout0_5ck179 = 3.3 time = 1800
* CHECK dout0_6 vdout0_6ck179 = 3.3 time = 1800
* CHECK dout0_7 vdout0_7ck179 = 0 time = 1800
* CHECK dout0_8 vdout0_8ck179 = 3.3 time = 1800
* CHECK dout0_9 vdout0_9ck179 = 3.3 time = 1800
* CHECK dout0_10 vdout0_10ck179 = 0 time = 1800
* CHECK dout0_11 vdout0_11ck179 = 3.3 time = 1800
* CHECK dout0_12 vdout0_12ck179 = 0 time = 1800
* CHECK dout0_13 vdout0_13ck179 = 3.3 time = 1800
* CHECK dout0_14 vdout0_14ck179 = 3.3 time = 1800
* CHECK dout0_15 vdout0_15ck179 = 3.3 time = 1800
* CHECK dout0_16 vdout0_16ck179 = 3.3 time = 1800
* CHECK dout0_17 vdout0_17ck179 = 0 time = 1800
* CHECK dout0_18 vdout0_18ck179 = 3.3 time = 1800
* CHECK dout0_19 vdout0_19ck179 = 0 time = 1800
* CHECK dout0_20 vdout0_20ck179 = 3.3 time = 1800
* CHECK dout0_21 vdout0_21ck179 = 3.3 time = 1800
* CHECK dout0_22 vdout0_22ck179 = 3.3 time = 1800
* CHECK dout0_23 vdout0_23ck179 = 0 time = 1800
* CHECK dout0_24 vdout0_24ck179 = 3.3 time = 1800
* CHECK dout0_25 vdout0_25ck179 = 0 time = 1800
* CHECK dout0_26 vdout0_26ck179 = 0 time = 1800
* CHECK dout0_27 vdout0_27ck179 = 0 time = 1800
* CHECK dout0_28 vdout0_28ck179 = 3.3 time = 1800
* CHECK dout0_29 vdout0_29ck179 = 3.3 time = 1800
* CHECK dout0_30 vdout0_30ck179 = 0 time = 1800
* CHECK dout0_31 vdout0_31ck179 = 3.3 time = 1800
* CHECK dout0_32 vdout0_32ck179 = 0 time = 1800
* CHECK dout0_0 vdout0_0ck180 = 3.3 time = 1810
* CHECK dout0_1 vdout0_1ck180 = 0 time = 1810
* CHECK dout0_2 vdout0_2ck180 = 3.3 time = 1810
* CHECK dout0_3 vdout0_3ck180 = 0 time = 1810
* CHECK dout0_4 vdout0_4ck180 = 0 time = 1810
* CHECK dout0_5 vdout0_5ck180 = 3.3 time = 1810
* CHECK dout0_6 vdout0_6ck180 = 3.3 time = 1810
* CHECK dout0_7 vdout0_7ck180 = 0 time = 1810
* CHECK dout0_8 vdout0_8ck180 = 3.3 time = 1810
* CHECK dout0_9 vdout0_9ck180 = 3.3 time = 1810
* CHECK dout0_10 vdout0_10ck180 = 0 time = 1810
* CHECK dout0_11 vdout0_11ck180 = 3.3 time = 1810
* CHECK dout0_12 vdout0_12ck180 = 0 time = 1810
* CHECK dout0_13 vdout0_13ck180 = 3.3 time = 1810
* CHECK dout0_14 vdout0_14ck180 = 3.3 time = 1810
* CHECK dout0_15 vdout0_15ck180 = 3.3 time = 1810
* CHECK dout0_16 vdout0_16ck180 = 3.3 time = 1810
* CHECK dout0_17 vdout0_17ck180 = 0 time = 1810
* CHECK dout0_18 vdout0_18ck180 = 3.3 time = 1810
* CHECK dout0_19 vdout0_19ck180 = 0 time = 1810
* CHECK dout0_20 vdout0_20ck180 = 3.3 time = 1810
* CHECK dout0_21 vdout0_21ck180 = 3.3 time = 1810
* CHECK dout0_22 vdout0_22ck180 = 3.3 time = 1810
* CHECK dout0_23 vdout0_23ck180 = 0 time = 1810
* CHECK dout0_24 vdout0_24ck180 = 3.3 time = 1810
* CHECK dout0_25 vdout0_25ck180 = 0 time = 1810
* CHECK dout0_26 vdout0_26ck180 = 0 time = 1810
* CHECK dout0_27 vdout0_27ck180 = 0 time = 1810
* CHECK dout0_28 vdout0_28ck180 = 3.3 time = 1810
* CHECK dout0_29 vdout0_29ck180 = 3.3 time = 1810
* CHECK dout0_30 vdout0_30ck180 = 0 time = 1810
* CHECK dout0_31 vdout0_31ck180 = 3.3 time = 1810
* CHECK dout0_32 vdout0_32ck180 = 0 time = 1810
* CHECK dout0_0 vdout0_0ck182 = 3.3 time = 1830
* CHECK dout0_1 vdout0_1ck182 = 0 time = 1830
* CHECK dout0_2 vdout0_2ck182 = 0 time = 1830
* CHECK dout0_3 vdout0_3ck182 = 0 time = 1830
* CHECK dout0_4 vdout0_4ck182 = 3.3 time = 1830
* CHECK dout0_5 vdout0_5ck182 = 3.3 time = 1830
* CHECK dout0_6 vdout0_6ck182 = 3.3 time = 1830
* CHECK dout0_7 vdout0_7ck182 = 0 time = 1830
* CHECK dout0_8 vdout0_8ck182 = 0 time = 1830
* CHECK dout0_9 vdout0_9ck182 = 0 time = 1830
* CHECK dout0_10 vdout0_10ck182 = 3.3 time = 1830
* CHECK dout0_11 vdout0_11ck182 = 3.3 time = 1830
* CHECK dout0_12 vdout0_12ck182 = 0 time = 1830
* CHECK dout0_13 vdout0_13ck182 = 0 time = 1830
* CHECK dout0_14 vdout0_14ck182 = 3.3 time = 1830
* CHECK dout0_15 vdout0_15ck182 = 3.3 time = 1830
* CHECK dout0_16 vdout0_16ck182 = 3.3 time = 1830
* CHECK dout0_17 vdout0_17ck182 = 0 time = 1830
* CHECK dout0_18 vdout0_18ck182 = 3.3 time = 1830
* CHECK dout0_19 vdout0_19ck182 = 3.3 time = 1830
* CHECK dout0_20 vdout0_20ck182 = 0 time = 1830
* CHECK dout0_21 vdout0_21ck182 = 0 time = 1830
* CHECK dout0_22 vdout0_22ck182 = 3.3 time = 1830
* CHECK dout0_23 vdout0_23ck182 = 3.3 time = 1830
* CHECK dout0_24 vdout0_24ck182 = 3.3 time = 1830
* CHECK dout0_25 vdout0_25ck182 = 0 time = 1830
* CHECK dout0_26 vdout0_26ck182 = 0 time = 1830
* CHECK dout0_27 vdout0_27ck182 = 0 time = 1830
* CHECK dout0_28 vdout0_28ck182 = 3.3 time = 1830
* CHECK dout0_29 vdout0_29ck182 = 0 time = 1830
* CHECK dout0_30 vdout0_30ck182 = 0 time = 1830
* CHECK dout0_31 vdout0_31ck182 = 3.3 time = 1830
* CHECK dout0_32 vdout0_32ck182 = 0 time = 1830
* CHECK dout0_0 vdout0_0ck183 = 3.3 time = 1840
* CHECK dout0_1 vdout0_1ck183 = 0 time = 1840
* CHECK dout0_2 vdout0_2ck183 = 0 time = 1840
* CHECK dout0_3 vdout0_3ck183 = 0 time = 1840
* CHECK dout0_4 vdout0_4ck183 = 3.3 time = 1840
* CHECK dout0_5 vdout0_5ck183 = 3.3 time = 1840
* CHECK dout0_6 vdout0_6ck183 = 3.3 time = 1840
* CHECK dout0_7 vdout0_7ck183 = 0 time = 1840
* CHECK dout0_8 vdout0_8ck183 = 0 time = 1840
* CHECK dout0_9 vdout0_9ck183 = 0 time = 1840
* CHECK dout0_10 vdout0_10ck183 = 3.3 time = 1840
* CHECK dout0_11 vdout0_11ck183 = 3.3 time = 1840
* CHECK dout0_12 vdout0_12ck183 = 0 time = 1840
* CHECK dout0_13 vdout0_13ck183 = 0 time = 1840
* CHECK dout0_14 vdout0_14ck183 = 3.3 time = 1840
* CHECK dout0_15 vdout0_15ck183 = 3.3 time = 1840
* CHECK dout0_16 vdout0_16ck183 = 3.3 time = 1840
* CHECK dout0_17 vdout0_17ck183 = 0 time = 1840
* CHECK dout0_18 vdout0_18ck183 = 3.3 time = 1840
* CHECK dout0_19 vdout0_19ck183 = 3.3 time = 1840
* CHECK dout0_20 vdout0_20ck183 = 0 time = 1840
* CHECK dout0_21 vdout0_21ck183 = 0 time = 1840
* CHECK dout0_22 vdout0_22ck183 = 3.3 time = 1840
* CHECK dout0_23 vdout0_23ck183 = 3.3 time = 1840
* CHECK dout0_24 vdout0_24ck183 = 3.3 time = 1840
* CHECK dout0_25 vdout0_25ck183 = 0 time = 1840
* CHECK dout0_26 vdout0_26ck183 = 0 time = 1840
* CHECK dout0_27 vdout0_27ck183 = 0 time = 1840
* CHECK dout0_28 vdout0_28ck183 = 3.3 time = 1840
* CHECK dout0_29 vdout0_29ck183 = 0 time = 1840
* CHECK dout0_30 vdout0_30ck183 = 0 time = 1840
* CHECK dout0_31 vdout0_31ck183 = 3.3 time = 1840
* CHECK dout0_32 vdout0_32ck183 = 0 time = 1840
* CHECK dout0_0 vdout0_0ck184 = 3.3 time = 1850
* CHECK dout0_1 vdout0_1ck184 = 0 time = 1850
* CHECK dout0_2 vdout0_2ck184 = 3.3 time = 1850
* CHECK dout0_3 vdout0_3ck184 = 0 time = 1850
* CHECK dout0_4 vdout0_4ck184 = 0 time = 1850
* CHECK dout0_5 vdout0_5ck184 = 3.3 time = 1850
* CHECK dout0_6 vdout0_6ck184 = 3.3 time = 1850
* CHECK dout0_7 vdout0_7ck184 = 0 time = 1850
* CHECK dout0_8 vdout0_8ck184 = 3.3 time = 1850
* CHECK dout0_9 vdout0_9ck184 = 3.3 time = 1850
* CHECK dout0_10 vdout0_10ck184 = 0 time = 1850
* CHECK dout0_11 vdout0_11ck184 = 3.3 time = 1850
* CHECK dout0_12 vdout0_12ck184 = 0 time = 1850
* CHECK dout0_13 vdout0_13ck184 = 3.3 time = 1850
* CHECK dout0_14 vdout0_14ck184 = 3.3 time = 1850
* CHECK dout0_15 vdout0_15ck184 = 3.3 time = 1850
* CHECK dout0_16 vdout0_16ck184 = 3.3 time = 1850
* CHECK dout0_17 vdout0_17ck184 = 0 time = 1850
* CHECK dout0_18 vdout0_18ck184 = 3.3 time = 1850
* CHECK dout0_19 vdout0_19ck184 = 0 time = 1850
* CHECK dout0_20 vdout0_20ck184 = 3.3 time = 1850
* CHECK dout0_21 vdout0_21ck184 = 3.3 time = 1850
* CHECK dout0_22 vdout0_22ck184 = 3.3 time = 1850
* CHECK dout0_23 vdout0_23ck184 = 0 time = 1850
* CHECK dout0_24 vdout0_24ck184 = 3.3 time = 1850
* CHECK dout0_25 vdout0_25ck184 = 0 time = 1850
* CHECK dout0_26 vdout0_26ck184 = 0 time = 1850
* CHECK dout0_27 vdout0_27ck184 = 0 time = 1850
* CHECK dout0_28 vdout0_28ck184 = 3.3 time = 1850
* CHECK dout0_29 vdout0_29ck184 = 3.3 time = 1850
* CHECK dout0_30 vdout0_30ck184 = 0 time = 1850
* CHECK dout0_31 vdout0_31ck184 = 3.3 time = 1850
* CHECK dout0_32 vdout0_32ck184 = 0 time = 1850
* CHECK dout0_0 vdout0_0ck185 = 3.3 time = 1860
* CHECK dout0_1 vdout0_1ck185 = 0 time = 1860
* CHECK dout0_2 vdout0_2ck185 = 3.3 time = 1860
* CHECK dout0_3 vdout0_3ck185 = 0 time = 1860
* CHECK dout0_4 vdout0_4ck185 = 0 time = 1860
* CHECK dout0_5 vdout0_5ck185 = 3.3 time = 1860
* CHECK dout0_6 vdout0_6ck185 = 3.3 time = 1860
* CHECK dout0_7 vdout0_7ck185 = 0 time = 1860
* CHECK dout0_8 vdout0_8ck185 = 3.3 time = 1860
* CHECK dout0_9 vdout0_9ck185 = 3.3 time = 1860
* CHECK dout0_10 vdout0_10ck185 = 0 time = 1860
* CHECK dout0_11 vdout0_11ck185 = 3.3 time = 1860
* CHECK dout0_12 vdout0_12ck185 = 0 time = 1860
* CHECK dout0_13 vdout0_13ck185 = 3.3 time = 1860
* CHECK dout0_14 vdout0_14ck185 = 3.3 time = 1860
* CHECK dout0_15 vdout0_15ck185 = 3.3 time = 1860
* CHECK dout0_16 vdout0_16ck185 = 3.3 time = 1860
* CHECK dout0_17 vdout0_17ck185 = 0 time = 1860
* CHECK dout0_18 vdout0_18ck185 = 3.3 time = 1860
* CHECK dout0_19 vdout0_19ck185 = 0 time = 1860
* CHECK dout0_20 vdout0_20ck185 = 3.3 time = 1860
* CHECK dout0_21 vdout0_21ck185 = 3.3 time = 1860
* CHECK dout0_22 vdout0_22ck185 = 3.3 time = 1860
* CHECK dout0_23 vdout0_23ck185 = 0 time = 1860
* CHECK dout0_24 vdout0_24ck185 = 3.3 time = 1860
* CHECK dout0_25 vdout0_25ck185 = 0 time = 1860
* CHECK dout0_26 vdout0_26ck185 = 0 time = 1860
* CHECK dout0_27 vdout0_27ck185 = 0 time = 1860
* CHECK dout0_28 vdout0_28ck185 = 3.3 time = 1860
* CHECK dout0_29 vdout0_29ck185 = 3.3 time = 1860
* CHECK dout0_30 vdout0_30ck185 = 0 time = 1860
* CHECK dout0_31 vdout0_31ck185 = 3.3 time = 1860
* CHECK dout0_32 vdout0_32ck185 = 0 time = 1860
* CHECK dout0_0 vdout0_0ck186 = 3.3 time = 1870
* CHECK dout0_1 vdout0_1ck186 = 0 time = 1870
* CHECK dout0_2 vdout0_2ck186 = 3.3 time = 1870
* CHECK dout0_3 vdout0_3ck186 = 0 time = 1870
* CHECK dout0_4 vdout0_4ck186 = 0 time = 1870
* CHECK dout0_5 vdout0_5ck186 = 3.3 time = 1870
* CHECK dout0_6 vdout0_6ck186 = 3.3 time = 1870
* CHECK dout0_7 vdout0_7ck186 = 0 time = 1870
* CHECK dout0_8 vdout0_8ck186 = 3.3 time = 1870
* CHECK dout0_9 vdout0_9ck186 = 3.3 time = 1870
* CHECK dout0_10 vdout0_10ck186 = 0 time = 1870
* CHECK dout0_11 vdout0_11ck186 = 3.3 time = 1870
* CHECK dout0_12 vdout0_12ck186 = 0 time = 1870
* CHECK dout0_13 vdout0_13ck186 = 3.3 time = 1870
* CHECK dout0_14 vdout0_14ck186 = 3.3 time = 1870
* CHECK dout0_15 vdout0_15ck186 = 3.3 time = 1870
* CHECK dout0_16 vdout0_16ck186 = 3.3 time = 1870
* CHECK dout0_17 vdout0_17ck186 = 0 time = 1870
* CHECK dout0_18 vdout0_18ck186 = 3.3 time = 1870
* CHECK dout0_19 vdout0_19ck186 = 0 time = 1870
* CHECK dout0_20 vdout0_20ck186 = 3.3 time = 1870
* CHECK dout0_21 vdout0_21ck186 = 3.3 time = 1870
* CHECK dout0_22 vdout0_22ck186 = 3.3 time = 1870
* CHECK dout0_23 vdout0_23ck186 = 0 time = 1870
* CHECK dout0_24 vdout0_24ck186 = 3.3 time = 1870
* CHECK dout0_25 vdout0_25ck186 = 0 time = 1870
* CHECK dout0_26 vdout0_26ck186 = 0 time = 1870
* CHECK dout0_27 vdout0_27ck186 = 0 time = 1870
* CHECK dout0_28 vdout0_28ck186 = 3.3 time = 1870
* CHECK dout0_29 vdout0_29ck186 = 3.3 time = 1870
* CHECK dout0_30 vdout0_30ck186 = 0 time = 1870
* CHECK dout0_31 vdout0_31ck186 = 3.3 time = 1870
* CHECK dout0_32 vdout0_32ck186 = 0 time = 1870
* CHECK dout0_0 vdout0_0ck189 = 3.3 time = 1900
* CHECK dout0_1 vdout0_1ck189 = 0 time = 1900
* CHECK dout0_2 vdout0_2ck189 = 0 time = 1900
* CHECK dout0_3 vdout0_3ck189 = 0 time = 1900
* CHECK dout0_4 vdout0_4ck189 = 3.3 time = 1900
* CHECK dout0_5 vdout0_5ck189 = 3.3 time = 1900
* CHECK dout0_6 vdout0_6ck189 = 3.3 time = 1900
* CHECK dout0_7 vdout0_7ck189 = 0 time = 1900
* CHECK dout0_8 vdout0_8ck189 = 0 time = 1900
* CHECK dout0_9 vdout0_9ck189 = 0 time = 1900
* CHECK dout0_10 vdout0_10ck189 = 3.3 time = 1900
* CHECK dout0_11 vdout0_11ck189 = 3.3 time = 1900
* CHECK dout0_12 vdout0_12ck189 = 0 time = 1900
* CHECK dout0_13 vdout0_13ck189 = 0 time = 1900
* CHECK dout0_14 vdout0_14ck189 = 3.3 time = 1900
* CHECK dout0_15 vdout0_15ck189 = 3.3 time = 1900
* CHECK dout0_16 vdout0_16ck189 = 3.3 time = 1900
* CHECK dout0_17 vdout0_17ck189 = 0 time = 1900
* CHECK dout0_18 vdout0_18ck189 = 3.3 time = 1900
* CHECK dout0_19 vdout0_19ck189 = 3.3 time = 1900
* CHECK dout0_20 vdout0_20ck189 = 0 time = 1900
* CHECK dout0_21 vdout0_21ck189 = 0 time = 1900
* CHECK dout0_22 vdout0_22ck189 = 3.3 time = 1900
* CHECK dout0_23 vdout0_23ck189 = 3.3 time = 1900
* CHECK dout0_24 vdout0_24ck189 = 3.3 time = 1900
* CHECK dout0_25 vdout0_25ck189 = 0 time = 1900
* CHECK dout0_26 vdout0_26ck189 = 0 time = 1900
* CHECK dout0_27 vdout0_27ck189 = 0 time = 1900
* CHECK dout0_28 vdout0_28ck189 = 3.3 time = 1900
* CHECK dout0_29 vdout0_29ck189 = 0 time = 1900
* CHECK dout0_30 vdout0_30ck189 = 0 time = 1900
* CHECK dout0_31 vdout0_31ck189 = 3.3 time = 1900
* CHECK dout0_32 vdout0_32ck189 = 0 time = 1900
* CHECK dout0_0 vdout0_0ck190 = 3.3 time = 1910
* CHECK dout0_1 vdout0_1ck190 = 0 time = 1910
* CHECK dout0_2 vdout0_2ck190 = 0 time = 1910
* CHECK dout0_3 vdout0_3ck190 = 0 time = 1910
* CHECK dout0_4 vdout0_4ck190 = 0 time = 1910
* CHECK dout0_5 vdout0_5ck190 = 0 time = 1910
* CHECK dout0_6 vdout0_6ck190 = 3.3 time = 1910
* CHECK dout0_7 vdout0_7ck190 = 3.3 time = 1910
* CHECK dout0_8 vdout0_8ck190 = 0 time = 1910
* CHECK dout0_9 vdout0_9ck190 = 3.3 time = 1910
* CHECK dout0_10 vdout0_10ck190 = 3.3 time = 1910
* CHECK dout0_11 vdout0_11ck190 = 3.3 time = 1910
* CHECK dout0_12 vdout0_12ck190 = 0 time = 1910
* CHECK dout0_13 vdout0_13ck190 = 3.3 time = 1910
* CHECK dout0_14 vdout0_14ck190 = 0 time = 1910
* CHECK dout0_15 vdout0_15ck190 = 3.3 time = 1910
* CHECK dout0_16 vdout0_16ck190 = 0 time = 1910
* CHECK dout0_17 vdout0_17ck190 = 3.3 time = 1910
* CHECK dout0_18 vdout0_18ck190 = 3.3 time = 1910
* CHECK dout0_19 vdout0_19ck190 = 0 time = 1910
* CHECK dout0_20 vdout0_20ck190 = 0 time = 1910
* CHECK dout0_21 vdout0_21ck190 = 3.3 time = 1910
* CHECK dout0_22 vdout0_22ck190 = 0 time = 1910
* CHECK dout0_23 vdout0_23ck190 = 3.3 time = 1910
* CHECK dout0_24 vdout0_24ck190 = 0 time = 1910
* CHECK dout0_25 vdout0_25ck190 = 3.3 time = 1910
* CHECK dout0_26 vdout0_26ck190 = 3.3 time = 1910
* CHECK dout0_27 vdout0_27ck190 = 0 time = 1910
* CHECK dout0_28 vdout0_28ck190 = 0 time = 1910
* CHECK dout0_29 vdout0_29ck190 = 3.3 time = 1910
* CHECK dout0_30 vdout0_30ck190 = 3.3 time = 1910
* CHECK dout0_31 vdout0_31ck190 = 0 time = 1910
* CHECK dout0_32 vdout0_32ck190 = 0 time = 1910
* CHECK dout0_0 vdout0_0ck191 = 3.3 time = 1920
* CHECK dout0_1 vdout0_1ck191 = 0 time = 1920
* CHECK dout0_2 vdout0_2ck191 = 0 time = 1920
* CHECK dout0_3 vdout0_3ck191 = 0 time = 1920
* CHECK dout0_4 vdout0_4ck191 = 3.3 time = 1920
* CHECK dout0_5 vdout0_5ck191 = 3.3 time = 1920
* CHECK dout0_6 vdout0_6ck191 = 3.3 time = 1920
* CHECK dout0_7 vdout0_7ck191 = 0 time = 1920
* CHECK dout0_8 vdout0_8ck191 = 0 time = 1920
* CHECK dout0_9 vdout0_9ck191 = 0 time = 1920
* CHECK dout0_10 vdout0_10ck191 = 3.3 time = 1920
* CHECK dout0_11 vdout0_11ck191 = 3.3 time = 1920
* CHECK dout0_12 vdout0_12ck191 = 0 time = 1920
* CHECK dout0_13 vdout0_13ck191 = 0 time = 1920
* CHECK dout0_14 vdout0_14ck191 = 3.3 time = 1920
* CHECK dout0_15 vdout0_15ck191 = 3.3 time = 1920
* CHECK dout0_16 vdout0_16ck191 = 3.3 time = 1920
* CHECK dout0_17 vdout0_17ck191 = 0 time = 1920
* CHECK dout0_18 vdout0_18ck191 = 3.3 time = 1920
* CHECK dout0_19 vdout0_19ck191 = 3.3 time = 1920
* CHECK dout0_20 vdout0_20ck191 = 0 time = 1920
* CHECK dout0_21 vdout0_21ck191 = 0 time = 1920
* CHECK dout0_22 vdout0_22ck191 = 3.3 time = 1920
* CHECK dout0_23 vdout0_23ck191 = 3.3 time = 1920
* CHECK dout0_24 vdout0_24ck191 = 3.3 time = 1920
* CHECK dout0_25 vdout0_25ck191 = 0 time = 1920
* CHECK dout0_26 vdout0_26ck191 = 0 time = 1920
* CHECK dout0_27 vdout0_27ck191 = 0 time = 1920
* CHECK dout0_28 vdout0_28ck191 = 3.3 time = 1920
* CHECK dout0_29 vdout0_29ck191 = 0 time = 1920
* CHECK dout0_30 vdout0_30ck191 = 0 time = 1920
* CHECK dout0_31 vdout0_31ck191 = 3.3 time = 1920
* CHECK dout0_32 vdout0_32ck191 = 0 time = 1920
* CHECK dout0_0 vdout0_0ck193 = 3.3 time = 1940
* CHECK dout0_1 vdout0_1ck193 = 0 time = 1940
* CHECK dout0_2 vdout0_2ck193 = 0 time = 1940
* CHECK dout0_3 vdout0_3ck193 = 0 time = 1940
* CHECK dout0_4 vdout0_4ck193 = 0 time = 1940
* CHECK dout0_5 vdout0_5ck193 = 0 time = 1940
* CHECK dout0_6 vdout0_6ck193 = 3.3 time = 1940
* CHECK dout0_7 vdout0_7ck193 = 3.3 time = 1940
* CHECK dout0_8 vdout0_8ck193 = 0 time = 1940
* CHECK dout0_9 vdout0_9ck193 = 3.3 time = 1940
* CHECK dout0_10 vdout0_10ck193 = 3.3 time = 1940
* CHECK dout0_11 vdout0_11ck193 = 3.3 time = 1940
* CHECK dout0_12 vdout0_12ck193 = 0 time = 1940
* CHECK dout0_13 vdout0_13ck193 = 3.3 time = 1940
* CHECK dout0_14 vdout0_14ck193 = 0 time = 1940
* CHECK dout0_15 vdout0_15ck193 = 3.3 time = 1940
* CHECK dout0_16 vdout0_16ck193 = 0 time = 1940
* CHECK dout0_17 vdout0_17ck193 = 3.3 time = 1940
* CHECK dout0_18 vdout0_18ck193 = 3.3 time = 1940
* CHECK dout0_19 vdout0_19ck193 = 0 time = 1940
* CHECK dout0_20 vdout0_20ck193 = 0 time = 1940
* CHECK dout0_21 vdout0_21ck193 = 3.3 time = 1940
* CHECK dout0_22 vdout0_22ck193 = 0 time = 1940
* CHECK dout0_23 vdout0_23ck193 = 3.3 time = 1940
* CHECK dout0_24 vdout0_24ck193 = 0 time = 1940
* CHECK dout0_25 vdout0_25ck193 = 3.3 time = 1940
* CHECK dout0_26 vdout0_26ck193 = 3.3 time = 1940
* CHECK dout0_27 vdout0_27ck193 = 0 time = 1940
* CHECK dout0_28 vdout0_28ck193 = 0 time = 1940
* CHECK dout0_29 vdout0_29ck193 = 3.3 time = 1940
* CHECK dout0_30 vdout0_30ck193 = 3.3 time = 1940
* CHECK dout0_31 vdout0_31ck193 = 0 time = 1940
* CHECK dout0_32 vdout0_32ck193 = 0 time = 1940
* CHECK dout0_0 vdout0_0ck194 = 3.3 time = 1950
* CHECK dout0_1 vdout0_1ck194 = 0 time = 1950
* CHECK dout0_2 vdout0_2ck194 = 0 time = 1950
* CHECK dout0_3 vdout0_3ck194 = 0 time = 1950
* CHECK dout0_4 vdout0_4ck194 = 3.3 time = 1950
* CHECK dout0_5 vdout0_5ck194 = 3.3 time = 1950
* CHECK dout0_6 vdout0_6ck194 = 3.3 time = 1950
* CHECK dout0_7 vdout0_7ck194 = 0 time = 1950
* CHECK dout0_8 vdout0_8ck194 = 0 time = 1950
* CHECK dout0_9 vdout0_9ck194 = 0 time = 1950
* CHECK dout0_10 vdout0_10ck194 = 3.3 time = 1950
* CHECK dout0_11 vdout0_11ck194 = 3.3 time = 1950
* CHECK dout0_12 vdout0_12ck194 = 0 time = 1950
* CHECK dout0_13 vdout0_13ck194 = 0 time = 1950
* CHECK dout0_14 vdout0_14ck194 = 3.3 time = 1950
* CHECK dout0_15 vdout0_15ck194 = 3.3 time = 1950
* CHECK dout0_16 vdout0_16ck194 = 3.3 time = 1950
* CHECK dout0_17 vdout0_17ck194 = 0 time = 1950
* CHECK dout0_18 vdout0_18ck194 = 3.3 time = 1950
* CHECK dout0_19 vdout0_19ck194 = 3.3 time = 1950
* CHECK dout0_20 vdout0_20ck194 = 0 time = 1950
* CHECK dout0_21 vdout0_21ck194 = 0 time = 1950
* CHECK dout0_22 vdout0_22ck194 = 3.3 time = 1950
* CHECK dout0_23 vdout0_23ck194 = 3.3 time = 1950
* CHECK dout0_24 vdout0_24ck194 = 3.3 time = 1950
* CHECK dout0_25 vdout0_25ck194 = 0 time = 1950
* CHECK dout0_26 vdout0_26ck194 = 0 time = 1950
* CHECK dout0_27 vdout0_27ck194 = 0 time = 1950
* CHECK dout0_28 vdout0_28ck194 = 3.3 time = 1950
* CHECK dout0_29 vdout0_29ck194 = 0 time = 1950
* CHECK dout0_30 vdout0_30ck194 = 0 time = 1950
* CHECK dout0_31 vdout0_31ck194 = 3.3 time = 1950
* CHECK dout0_32 vdout0_32ck194 = 0 time = 1950
* CHECK dout0_0 vdout0_0ck196 = 3.3 time = 1970
* CHECK dout0_1 vdout0_1ck196 = 0 time = 1970
* CHECK dout0_2 vdout0_2ck196 = 0 time = 1970
* CHECK dout0_3 vdout0_3ck196 = 0 time = 1970
* CHECK dout0_4 vdout0_4ck196 = 3.3 time = 1970
* CHECK dout0_5 vdout0_5ck196 = 3.3 time = 1970
* CHECK dout0_6 vdout0_6ck196 = 3.3 time = 1970
* CHECK dout0_7 vdout0_7ck196 = 0 time = 1970
* CHECK dout0_8 vdout0_8ck196 = 0 time = 1970
* CHECK dout0_9 vdout0_9ck196 = 0 time = 1970
* CHECK dout0_10 vdout0_10ck196 = 3.3 time = 1970
* CHECK dout0_11 vdout0_11ck196 = 3.3 time = 1970
* CHECK dout0_12 vdout0_12ck196 = 0 time = 1970
* CHECK dout0_13 vdout0_13ck196 = 0 time = 1970
* CHECK dout0_14 vdout0_14ck196 = 3.3 time = 1970
* CHECK dout0_15 vdout0_15ck196 = 3.3 time = 1970
* CHECK dout0_16 vdout0_16ck196 = 3.3 time = 1970
* CHECK dout0_17 vdout0_17ck196 = 0 time = 1970
* CHECK dout0_18 vdout0_18ck196 = 3.3 time = 1970
* CHECK dout0_19 vdout0_19ck196 = 3.3 time = 1970
* CHECK dout0_20 vdout0_20ck196 = 0 time = 1970
* CHECK dout0_21 vdout0_21ck196 = 0 time = 1970
* CHECK dout0_22 vdout0_22ck196 = 3.3 time = 1970
* CHECK dout0_23 vdout0_23ck196 = 3.3 time = 1970
* CHECK dout0_24 vdout0_24ck196 = 3.3 time = 1970
* CHECK dout0_25 vdout0_25ck196 = 0 time = 1970
* CHECK dout0_26 vdout0_26ck196 = 0 time = 1970
* CHECK dout0_27 vdout0_27ck196 = 0 time = 1970
* CHECK dout0_28 vdout0_28ck196 = 3.3 time = 1970
* CHECK dout0_29 vdout0_29ck196 = 0 time = 1970
* CHECK dout0_30 vdout0_30ck196 = 0 time = 1970
* CHECK dout0_31 vdout0_31ck196 = 3.3 time = 1970
* CHECK dout0_32 vdout0_32ck196 = 0 time = 1970
* CHECK dout0_0 vdout0_0ck197 = 3.3 time = 1980
* CHECK dout0_1 vdout0_1ck197 = 0 time = 1980
* CHECK dout0_2 vdout0_2ck197 = 0 time = 1980
* CHECK dout0_3 vdout0_3ck197 = 0 time = 1980
* CHECK dout0_4 vdout0_4ck197 = 3.3 time = 1980
* CHECK dout0_5 vdout0_5ck197 = 3.3 time = 1980
* CHECK dout0_6 vdout0_6ck197 = 3.3 time = 1980
* CHECK dout0_7 vdout0_7ck197 = 0 time = 1980
* CHECK dout0_8 vdout0_8ck197 = 0 time = 1980
* CHECK dout0_9 vdout0_9ck197 = 0 time = 1980
* CHECK dout0_10 vdout0_10ck197 = 3.3 time = 1980
* CHECK dout0_11 vdout0_11ck197 = 3.3 time = 1980
* CHECK dout0_12 vdout0_12ck197 = 0 time = 1980
* CHECK dout0_13 vdout0_13ck197 = 0 time = 1980
* CHECK dout0_14 vdout0_14ck197 = 3.3 time = 1980
* CHECK dout0_15 vdout0_15ck197 = 3.3 time = 1980
* CHECK dout0_16 vdout0_16ck197 = 3.3 time = 1980
* CHECK dout0_17 vdout0_17ck197 = 0 time = 1980
* CHECK dout0_18 vdout0_18ck197 = 3.3 time = 1980
* CHECK dout0_19 vdout0_19ck197 = 3.3 time = 1980
* CHECK dout0_20 vdout0_20ck197 = 0 time = 1980
* CHECK dout0_21 vdout0_21ck197 = 0 time = 1980
* CHECK dout0_22 vdout0_22ck197 = 3.3 time = 1980
* CHECK dout0_23 vdout0_23ck197 = 3.3 time = 1980
* CHECK dout0_24 vdout0_24ck197 = 3.3 time = 1980
* CHECK dout0_25 vdout0_25ck197 = 0 time = 1980
* CHECK dout0_26 vdout0_26ck197 = 0 time = 1980
* CHECK dout0_27 vdout0_27ck197 = 0 time = 1980
* CHECK dout0_28 vdout0_28ck197 = 3.3 time = 1980
* CHECK dout0_29 vdout0_29ck197 = 0 time = 1980
* CHECK dout0_30 vdout0_30ck197 = 0 time = 1980
* CHECK dout0_31 vdout0_31ck197 = 3.3 time = 1980
* CHECK dout0_32 vdout0_32ck197 = 0 time = 1980
* CHECK dout0_0 vdout0_0ck198 = 0 time = 1990
* CHECK dout0_1 vdout0_1ck198 = 0 time = 1990
* CHECK dout0_2 vdout0_2ck198 = 0 time = 1990
* CHECK dout0_3 vdout0_3ck198 = 3.3 time = 1990
* CHECK dout0_4 vdout0_4ck198 = 0 time = 1990
* CHECK dout0_5 vdout0_5ck198 = 3.3 time = 1990
* CHECK dout0_6 vdout0_6ck198 = 3.3 time = 1990
* CHECK dout0_7 vdout0_7ck198 = 0 time = 1990
* CHECK dout0_8 vdout0_8ck198 = 0 time = 1990
* CHECK dout0_9 vdout0_9ck198 = 3.3 time = 1990
* CHECK dout0_10 vdout0_10ck198 = 3.3 time = 1990
* CHECK dout0_11 vdout0_11ck198 = 3.3 time = 1990
* CHECK dout0_12 vdout0_12ck198 = 0 time = 1990
* CHECK dout0_13 vdout0_13ck198 = 3.3 time = 1990
* CHECK dout0_14 vdout0_14ck198 = 0 time = 1990
* CHECK dout0_15 vdout0_15ck198 = 3.3 time = 1990
* CHECK dout0_16 vdout0_16ck198 = 3.3 time = 1990
* CHECK dout0_17 vdout0_17ck198 = 3.3 time = 1990
* CHECK dout0_18 vdout0_18ck198 = 0 time = 1990
* CHECK dout0_19 vdout0_19ck198 = 3.3 time = 1990
* CHECK dout0_20 vdout0_20ck198 = 3.3 time = 1990
* CHECK dout0_21 vdout0_21ck198 = 0 time = 1990
* CHECK dout0_22 vdout0_22ck198 = 3.3 time = 1990
* CHECK dout0_23 vdout0_23ck198 = 0 time = 1990
* CHECK dout0_24 vdout0_24ck198 = 3.3 time = 1990
* CHECK dout0_25 vdout0_25ck198 = 3.3 time = 1990
* CHECK dout0_26 vdout0_26ck198 = 0 time = 1990
* CHECK dout0_27 vdout0_27ck198 = 0 time = 1990
* CHECK dout0_28 vdout0_28ck198 = 0 time = 1990
* CHECK dout0_29 vdout0_29ck198 = 3.3 time = 1990
* CHECK dout0_30 vdout0_30ck198 = 0 time = 1990
* CHECK dout0_31 vdout0_31ck198 = 0 time = 1990
* CHECK dout0_32 vdout0_32ck198 = 0 time = 1990
* CHECK dout0_0 vdout0_0ck201 = 0 time = 2020
* CHECK dout0_1 vdout0_1ck201 = 0 time = 2020
* CHECK dout0_2 vdout0_2ck201 = 0 time = 2020
* CHECK dout0_3 vdout0_3ck201 = 3.3 time = 2020
* CHECK dout0_4 vdout0_4ck201 = 0 time = 2020
* CHECK dout0_5 vdout0_5ck201 = 3.3 time = 2020
* CHECK dout0_6 vdout0_6ck201 = 3.3 time = 2020
* CHECK dout0_7 vdout0_7ck201 = 0 time = 2020
* CHECK dout0_8 vdout0_8ck201 = 0 time = 2020
* CHECK dout0_9 vdout0_9ck201 = 3.3 time = 2020
* CHECK dout0_10 vdout0_10ck201 = 3.3 time = 2020
* CHECK dout0_11 vdout0_11ck201 = 3.3 time = 2020
* CHECK dout0_12 vdout0_12ck201 = 0 time = 2020
* CHECK dout0_13 vdout0_13ck201 = 3.3 time = 2020
* CHECK dout0_14 vdout0_14ck201 = 0 time = 2020
* CHECK dout0_15 vdout0_15ck201 = 3.3 time = 2020
* CHECK dout0_16 vdout0_16ck201 = 3.3 time = 2020
* CHECK dout0_17 vdout0_17ck201 = 3.3 time = 2020
* CHECK dout0_18 vdout0_18ck201 = 0 time = 2020
* CHECK dout0_19 vdout0_19ck201 = 3.3 time = 2020
* CHECK dout0_20 vdout0_20ck201 = 3.3 time = 2020
* CHECK dout0_21 vdout0_21ck201 = 0 time = 2020
* CHECK dout0_22 vdout0_22ck201 = 3.3 time = 2020
* CHECK dout0_23 vdout0_23ck201 = 0 time = 2020
* CHECK dout0_24 vdout0_24ck201 = 3.3 time = 2020
* CHECK dout0_25 vdout0_25ck201 = 3.3 time = 2020
* CHECK dout0_26 vdout0_26ck201 = 0 time = 2020
* CHECK dout0_27 vdout0_27ck201 = 0 time = 2020
* CHECK dout0_28 vdout0_28ck201 = 0 time = 2020
* CHECK dout0_29 vdout0_29ck201 = 3.3 time = 2020
* CHECK dout0_30 vdout0_30ck201 = 0 time = 2020
* CHECK dout0_31 vdout0_31ck201 = 0 time = 2020
* CHECK dout0_32 vdout0_32ck201 = 0 time = 2020
.include /home/v62893/mydata/OpenRAM/OpenRAM/sram_output_sky130/functional_meas.sp
* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
