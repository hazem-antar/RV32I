* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/v62893/mydata/OpenRAM/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/v62893/mydata/OpenRAM/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "/tmp/openram_v62893_4529_temp/sram.sp"

* Global Power Supplies
Vvdd vdd 0 3.3

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_32b_256_1rw_freepdk45 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 vdd gnd sram_32b_256_1rw_freepdk45

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f

* Important signals for debug
* bl:	xsram:xbank0:bl_0_0
* br:	xsram:xbank0:br_0_0
* s_en:	xsram:s_en
* q:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q
* qbar:	xsram:xbank0:xbitcell_array:xbitcell_array:xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 01110110011110010111101010001011  to  address 00000000 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 01011011110100100011100110000000  to  address 11111110 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 01001111111110100001111110100000  to  address 11111110 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 01110110011110010111101010001011 from address 00000000 (from port 0) during cycle 4 (20ns - 25ns)
*	Writing 00001000101010010010101001111111  to  address 00000000 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 01001111111110100001111110100000 from address 11111110 (from port 0) during cycle 7 (35ns - 40ns)
*	Writing 01011110110000010101001111100010  to  address 11111110 (from port 0) during cycle 9 (45ns - 50ns)
*	Reading 01011110110000010101001111100010 from address 11111110 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 01011110110000010101001111100010 from address 11111110 (from port 0) during cycle 12 (60ns - 65ns)
*	Reading 01011110110000010101001111100010 from address 11111110 (from port 0) during cycle 13 (65ns - 70ns)
*	Reading 00001000101010010010101001111111 from address 00000000 (from port 0) during cycle 14 (70ns - 75ns)
*	Writing 10101010000111010111011001001001  to  address 00000000 (from port 0) during cycle 15 (75ns - 80ns)
*	Reading 01011110110000010101001111100010 from address 11111110 (from port 0) during cycle 16 (80ns - 85ns)
*	Writing 11111011011101010011000101001111  to  address 00000000 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 11111011011101010011000101001111 from address 00000000 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 11111011011101010011000101001111 from address 00000000 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 11111011011101010011000101001111 from address 00000000 (from port 0) during cycle 20 (100ns - 105ns)
*	Writing 10001100100001100100011000011010  to  address 00000000 (from port 0) during cycle 21 (105ns - 110ns)
*	Reading 10001100100001100100011000011010 from address 00000000 (from port 0) during cycle 22 (110ns - 115ns)
*	Writing 10111011010101110000010101000000  to  address 11111110 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 10111011010101110000010101000000 from address 11111110 (from port 0) during cycle 24 (120ns - 125ns)
*	Reading 10001100100001100100011000011010 from address 00000000 (from port 0) during cycle 25 (125ns - 130ns)
*	Reading 10111011010101110000010101000000 from address 11111110 (from port 0) during cycle 26 (130ns - 135ns)
*	Reading 10001100100001100100011000011010 from address 00000000 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 10001100100001100100011000011010 from address 00000000 (from port 0) during cycle 28 (140ns - 145ns)
*	Reading 10001100100001100100011000011010 from address 00000000 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 10111011010101110000010101000000 from address 11111110 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 10001100100001100100011000011010 from address 00000000 (from port 0) during cycle 31 (155ns - 160ns)
*	Reading 10111011010101110000010101000000 from address 11111110 (from port 0) during cycle 34 (170ns - 175ns)
*	Writing 01111001101101100011101110011101  to  address 00000000 (from port 0) during cycle 35 (175ns - 180ns)
*	Writing 10010110000011100111111010000001  to  address 11111110 (from port 0) during cycle 36 (180ns - 185ns)
*	Writing 10011011011000000100111100100000  to  address 00000000 (from port 0) during cycle 37 (185ns - 190ns)
*	Reading 10011011011000000100111100100000 from address 00000000 (from port 0) during cycle 38 (190ns - 195ns)
*	Reading 10010110000011100111111010000001 from address 11111110 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 10010110000011100111111010000001 from address 11111110 (from port 0) during cycle 41 (205ns - 210ns)
*	Reading 10010110000011100111111010000001 from address 11111110 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing 01010111000000001000101100000101  to  address 00000000 (from port 0) during cycle 45 (225ns - 230ns)
*	Writing 10110001000100000001000001110100  to  address 00000000 (from port 0) during cycle 46 (230ns - 235ns)
*	Reading 10010110000011100111111010000001 from address 11111110 (from port 0) during cycle 47 (235ns - 240ns)
*	Reading 10110001000100000001000001110100 from address 00000000 (from port 0) during cycle 48 (240ns - 245ns)
*	Writing 00110111011010000011001110101000  to  address 00000000 (from port 0) during cycle 49 (245ns - 250ns)
*	Writing 00110011101000101111101111111100  to  address 11111110 (from port 0) during cycle 50 (250ns - 255ns)
*	Writing 01011111111100110101000110010101  to  address 11111110 (from port 0) during cycle 51 (255ns - 260ns)
*	Reading 01011111111100110101000110010101 from address 11111110 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 01011111111100110101000110010101 from address 11111110 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 01011111111100110101000110010101 from address 11111110 (from port 0) during cycle 55 (275ns - 280ns)
*	Writing 00110100111000111001101110111000  to  address 11111110 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 00110111011010000011001110101000 from address 00000000 (from port 0) during cycle 57 (285ns - 290ns)
*	Reading 00110100111000111001101110111000 from address 11111110 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 11110000011110001000100111011101  to  address 11111110 (from port 0) during cycle 60 (300ns - 305ns)
*	Writing 10101110111011011111011001010101  to  address 00000000 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 10101110111011011111011001010101 from address 00000000 (from port 0) during cycle 62 (310ns - 315ns)
*	Reading 11110000011110001000100111011101 from address 11111110 (from port 0) during cycle 63 (315ns - 320ns)
*	Writing 01110111000011100101101110110101  to  address 00000000 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 01010110110111001010011010000111  to  address 00000000 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 01010110110111001010011010000111 from address 00000000 (from port 0) during cycle 69 (345ns - 350ns)
*	Reading 01010110110111001010011010000111 from address 00000000 (from port 0) during cycle 70 (350ns - 355ns)
*	Writing 11010010110010111011100111111011  to  address 00000000 (from port 0) during cycle 72 (360ns - 365ns)
*	Reading 11110000011110001000100111011101 from address 11111110 (from port 0) during cycle 73 (365ns - 370ns)
*	Reading 11010010110010111011100111111011 from address 00000000 (from port 0) during cycle 74 (370ns - 375ns)
*	Reading 11010010110010111011100111111011 from address 00000000 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 11010010110010111011100111111011 from address 00000000 (from port 0) during cycle 76 (380ns - 385ns)
*	Reading 11010010110010111011100111111011 from address 00000000 (from port 0) during cycle 77 (385ns - 390ns)
*	Reading 11010010110010111011100111111011 from address 00000000 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 11111111100001101010110011010000  to  address 00000000 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 11111111100001101010110011010000 from address 00000000 (from port 0) during cycle 84 (420ns - 425ns)
*	Reading 11110000011110001000100111011101 from address 11111110 (from port 0) during cycle 85 (425ns - 430ns)
*	Reading 11111111100001101010110011010000 from address 00000000 (from port 0) during cycle 86 (430ns - 435ns)
*	Reading 11110000011110001000100111011101 from address 11111110 (from port 0) during cycle 88 (440ns - 445ns)
*	Writing 01101101011010100010100001010000  to  address 00000000 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 01100100011010001101010111010111  to  address 00000000 (from port 0) during cycle 93 (465ns - 470ns)
*	Writing 01111000100000010101011000000010  to  address 11111110 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 95 (475ns - 480ns)
*	Writing 11011100000111011111001010110000  to  address 00000000 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 100 (500ns - 505ns)
*	Writing 00011101011001101010101011011010  to  address 00000000 (from port 0) during cycle 101 (505ns - 510ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 103 (515ns - 520ns)
*	Reading 00011101011001101010101011011010 from address 00000000 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 00011101011001101010101011011010 from address 00000000 (from port 0) during cycle 105 (525ns - 530ns)
*	Writing 10110101110000011100110000110100  to  address 00000000 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 108 (540ns - 545ns)
*	Writing 10111100000001111111001111101011  to  address 00000000 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 10111100000001111111001111101011 from address 00000000 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 10111100000001111111001111101011 from address 00000000 (from port 0) during cycle 111 (555ns - 560ns)
*	Writing 00101100001011000110000100100110  to  address 00000000 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 00101100001011000110000100100110 from address 00000000 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 117 (585ns - 590ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 119 (595ns - 600ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 01111000100000010101011000000010 from address 11111110 (from port 0) during cycle 122 (610ns - 615ns)
*	Writing 00111100000001100111010011011110  to  address 11111110 (from port 0) during cycle 123 (615ns - 620ns)
*	Writing 01101101101010010111010101111001  to  address 11111110 (from port 0) during cycle 124 (620ns - 625ns)
*	Reading 00101100001011000110000100100110 from address 00000000 (from port 0) during cycle 125 (625ns - 630ns)
*	Writing 11100111100010001101101000100111  to  address 00000000 (from port 0) during cycle 128 (640ns - 645ns)
*	Writing 00010001001010110111011100100011  to  address 00000000 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing 10111011111011000000100000011000  to  address 00000000 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 10111011111011000000100000011000 from address 00000000 (from port 0) during cycle 132 (660ns - 665ns)
*	Reading 01101101101010010111010101111001 from address 11111110 (from port 0) during cycle 133 (665ns - 670ns)
*	Reading 10111011111011000000100000011000 from address 00000000 (from port 0) during cycle 134 (670ns - 675ns)
*	Reading 10111011111011000000100000011000 from address 00000000 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 10111011111011000000100000011000 from address 00000000 (from port 0) during cycle 136 (680ns - 685ns)
*	Writing 11100110101011101011000101101100  to  address 00000000 (from port 0) during cycle 137 (685ns - 690ns)
*	Writing 11011001100001001001100110011101  to  address 00000000 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 01100101110011010110110101110000  to  address 00000000 (from port 0) during cycle 140 (700ns - 705ns)
*	Reading 01100101110011010110110101110000 from address 00000000 (from port 0) during cycle 141 (705ns - 710ns)
*	Writing 10000110100101011011011110011110  to  address 00000000 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 10000110100101011011011110011110 from address 00000000 (from port 0) during cycle 143 (715ns - 720ns)
*	Writing 01110100110101110111110101011110  to  address 00000000 (from port 0) during cycle 144 (720ns - 725ns)
*	Reading 01101101101010010111010101111001 from address 11111110 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing 00101010011110010100011100111011  to  address 00000000 (from port 0) during cycle 147 (735ns - 740ns)
*	Writing 10001110110000111001100001010101  to  address 11111110 (from port 0) during cycle 148 (740ns - 745ns)
*	Writing 01110000000100100110110110111011  to  address 11111110 (from port 0) during cycle 149 (745ns - 750ns)
*	Reading 01110000000100100110110110111011 from address 11111110 (from port 0) during cycle 152 (760ns - 765ns)
*	Reading 01110000000100100110110110111011 from address 11111110 (from port 0) during cycle 153 (765ns - 770ns)
*	Reading 00101010011110010100011100111011 from address 00000000 (from port 0) during cycle 154 (770ns - 775ns)
*	Writing 11010100100100101011001110111110  to  address 00000000 (from port 0) during cycle 155 (775ns - 780ns)
*	Reading 11010100100100101011001110111110 from address 00000000 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 11010100100100101011001110111110 from address 00000000 (from port 0) during cycle 158 (790ns - 795ns)
*	Reading 11010100100100101011001110111110 from address 00000000 (from port 0) during cycle 160 (800ns - 805ns)
*	Writing 00001101001011011000100101101100  to  address 00000000 (from port 0) during cycle 162 (810ns - 815ns)
*	Writing 10110011100011001100110101000001  to  address 00000000 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 01110000000100100110110110111011 from address 11111110 (from port 0) during cycle 165 (825ns - 830ns)
*	Writing 01100101010110001011011000000001  to  address 11111110 (from port 0) during cycle 166 (830ns - 835ns)
*	Reading 01100101010110001011011000000001 from address 11111110 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 01100101010110001011011000000001 from address 11111110 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 10110011100011001100110101000001 from address 00000000 (from port 0) during cycle 170 (850ns - 855ns)
*	Reading 10110011100011001100110101000001 from address 00000000 (from port 0) during cycle 172 (860ns - 865ns)
*	Writing 01110100100000001000110010101110  to  address 00000000 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 01100101010110001011011000000001 from address 11111110 (from port 0) during cycle 174 (870ns - 875ns)
*	Reading 01100101010110001011011000000001 from address 11111110 (from port 0) during cycle 176 (880ns - 885ns)
*	Reading 01110100100000001000110010101110 from address 00000000 (from port 0) during cycle 177 (885ns - 890ns)
*	Writing 00011100100000010110110110000111  to  address 11111110 (from port 0) during cycle 178 (890ns - 895ns)
*	Writing 00010101101100001110110000000100  to  address 00000000 (from port 0) during cycle 179 (895ns - 900ns)
*	Reading 00011100100000010110110110000111 from address 11111110 (from port 0) during cycle 180 (900ns - 905ns)
*	Reading 00010101101100001110110000000100 from address 00000000 (from port 0) during cycle 181 (905ns - 910ns)
*	Reading 00010101101100001110110000000100 from address 00000000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 00010101101100001110110000000100 from address 00000000 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 00011100100000010110110110000111 from address 11111110 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 00010101101100001110110000000100 from address 00000000 (from port 0) during cycle 187 (935ns - 940ns)
*	Reading 00011100100000010110110110000111 from address 11111110 (from port 0) during cycle 188 (940ns - 945ns)
*	Reading 00010101101100001110110000000100 from address 00000000 (from port 0) during cycle 189 (945ns - 950ns)
*	Reading 00011100100000010110110110000111 from address 11111110 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 10100001011000010100101100001111  to  address 00000000 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 00011100100000010110110110000111 from address 11111110 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 10100001011000010100101100001111 from address 00000000 (from port 0) during cycle 194 (970ns - 975ns)
*	Writing 01101101111101110101001110101001  to  address 00000000 (from port 0) during cycle 196 (980ns - 985ns)
*	Reading 01101101111101110101001110101001 from address 00000000 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 01101101111101110101001110101001 from address 00000000 (from port 0) during cycle 198 (990ns - 995ns)
*	Reading 00011100100000010110110110000111 from address 11111110 (from port 0) during cycle 199 (995ns - 1000ns)
*	Reading 01101101111101110101001110101001 from address 00000000 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Writing 10000010011100111100010001011101  to  address 11111110 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Writing 10010101011100010110000110100000  to  address 11111110 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Writing 10111100111100001010101100010110  to  address 00000000 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 3.3v 229.745n 3.3v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 0.0v 894.745n 0.0v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 3.3v 229.745n 3.3v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 3.3v 654.745n 3.3v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 1), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 1), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 3.3v 249.745n 3.3v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 0), (540, 0), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 3.3v 29.745n 3.3v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 3.3v 739.745n 3.3v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 3.3v 814.745n 3.3v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 3.3v 229.745n 3.3v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 3.3v 509.745n 3.3v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 3.3v 619.745n 3.3v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 3.3v 654.745n 3.3v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 3.3v 894.745n 3.3v 894.755n 3.3v 899.745n 3.3v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 0), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 3.3v 249.745n 3.3v 249.755n 3.3v 254.745n 3.3v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 3.3v 284.745n 3.3v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 3.3v 339.745n 3.3v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 3.3v 564.745n 3.3v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 3.3v 739.745n 3.3v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 1), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 1), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 1), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 3.3v 9.745n 3.3v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 3.3v 179.745n 3.3v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 3.3v 229.745n 3.3v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 3.3v 339.745n 3.3v 339.755n 3.3v 344.745n 3.3v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 3.3v 454.745n 3.3v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 3.3v 469.745n 3.3v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 3.3v 624.745n 3.3v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 3.3v 704.745n 3.3v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 3.3v 724.745n 3.3v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 3.3v 869.745n 3.3v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 3.3v 984.745n 3.3v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 1), (825, 1), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 3.3v 79.745n 3.3v 79.755n 3.3v 84.745n 3.3v 84.755n 3.3v 89.745n 3.3v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 3.3v 109.745n 3.3v 109.755n 3.3v 114.745n 3.3v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 3.3v 189.745n 3.3v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 3.3v 234.745n 3.3v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 3.3v 304.745n 3.3v 304.755n 3.3v 309.745n 3.3v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 3.3v 364.745n 3.3v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 3.3v 419.745n 3.3v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 3.3v 489.745n 3.3v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 3.3v 534.745n 3.3v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 3.3v 549.745n 3.3v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 3.3v 644.745n 3.3v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 3.3v 659.745n 3.3v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 3.3v 689.745n 3.3v 689.755n 3.3v 694.745n 3.3v 694.755n 3.3v 699.745n 3.3v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 3.3v 714.745n 3.3v 714.755n 3.3v 719.745n 3.3v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 3.3v 779.745n 3.3v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 3.3v 824.745n 3.3v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 3.3v 964.745n 3.3v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 3.3v 1019.745n 3.3v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 0), (25, 0), (30, 0), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 0), (145, 0), (150, 1), (155, 0), (160, 0), (165, 0), (170, 1), (175, 0), (180, 1), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 0), (245, 0), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 0), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 0), (435, 0), (440, 1), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 1), (500, 1), (505, 0), (510, 0), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 0), (855, 0), (860, 0), (865, 0), (870, 1), (875, 1), (880, 1), (885, 0), (890, 1), (895, 0), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 1), (930, 1), (935, 0), (940, 1), (945, 0), (950, 1), (955, 1), (960, 0), (965, 1), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 0), (1020, 0), (1025, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 3.3v 14.745n 3.3v 14.755n 3.3v 19.745n 3.3v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 3.3v 49.745n 3.3v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 3.3v 119.745n 3.3v 119.755n 3.3v 124.745n 3.3v 124.755n 0.0v 129.745n 0.0v 129.755n 3.3v 134.745n 3.3v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 3.3v 154.745n 3.3v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 3.3v 184.745n 3.3v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 3.3v 254.745n 3.3v 254.755n 3.3v 259.745n 3.3v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 3.3v 284.745n 3.3v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 3.3v 299.745n 3.3v 299.755n 3.3v 304.745n 3.3v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 3.3v 429.745n 3.3v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 3.3v 474.745n 3.3v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 3.3v 519.745n 3.3v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 3.3v 619.745n 3.3v 619.755n 3.3v 624.745n 3.3v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 3.3v 669.745n 3.3v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 3.3v 744.745n 3.3v 744.755n 3.3v 749.745n 3.3v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 3.3v 834.745n 3.3v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 0.0v 889.745n 0.0v 889.755n 3.3v 894.745n 3.3v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 3.3v 944.745n 3.3v 944.755n 0.0v 949.745n 0.0v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 3.3v 999.745n 3.3v 999.755n 0.0v 1004.745n 0.0v 1004.755n 3.3v 1009.745n 3.3v 1009.755n 3.3v 1014.745n 3.3v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 1), (35, 0), (40, 1), (45, 0), (50, 1), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 1), (165, 1), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 1), (205, 0), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 1), (270, 0), (275, 0), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 1), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 1), (395, 1), (400, 1), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 0), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 0), (480, 1), (485, 0), (490, 1), (495, 0), (500, 0), (505, 0), (510, 1), (515, 0), (520, 0), (525, 0), (530, 0), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 1), (570, 0), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 1), (790, 0), (795, 1), (800, 0), (805, 1), (810, 0), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 0), (845, 0), (850, 0), (855, 1), (860, 0), (865, 0), (870, 0), (875, 1), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 1), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 1), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 3.3v 4.745n 3.3v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 3.3v 34.745n 3.3v 34.755n 0.0v 39.745n 0.0v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 3.3v 54.745n 3.3v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 3.3v 204.745n 3.3v 204.755n 0.0v 209.745n 0.0v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 3.3v 269.745n 3.3v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 3.3v 294.745n 3.3v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 0.0v 409.745n 0.0v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 3.3v 439.745n 3.3v 439.755n 0.0v 444.745n 0.0v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 3.3v 494.745n 3.3v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 3.3v 514.745n 3.3v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 3.3v 539.745n 3.3v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 3.3v 569.745n 3.3v 569.755n 0.0v 574.745n 0.0v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 3.3v 729.745n 3.3v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 3.3v 789.745n 3.3v 789.755n 0.0v 794.745n 0.0v 794.755n 3.3v 799.745n 3.3v 799.755n 0.0v 804.745n 0.0v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 3.3v 839.745n 3.3v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 3.3v 859.745n 3.3v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 3.3v 879.745n 3.3v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 3.3v 919.745n 3.3v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 3.3v 934.745n 3.3v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 3.3v 979.745n 3.3v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 1), (85, 0), (90, 1), (95, 1), (100, 1), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 0), (180, 0), (185, 0), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 0), (230, 0), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 0), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 0), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 0), (455, 1), (460, 1), (465, 0), (470, 0), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 0), (510, 1), (515, 1), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 0), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 0), (645, 1), (650, 0), (655, 0), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 1), (710, 0), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 0), (815, 1), (820, 0), (825, 1), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 1), (880, 1), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 1), (970, 1), (975, 1), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 3.3v 4.745n 3.3v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 3.3v 24.745n 3.3v 24.755n 0.0v 29.745n 0.0v 29.755n 3.3v 34.745n 3.3v 34.755n 3.3v 39.745n 3.3v 39.755n 3.3v 44.745n 3.3v 44.755n 0.0v 49.745n 0.0v 49.755n 3.3v 54.745n 3.3v 54.755n 3.3v 59.745n 3.3v 59.755n 3.3v 64.745n 3.3v 64.755n 3.3v 69.745n 3.3v 69.755n 3.3v 74.745n 3.3v 74.755n 0.0v 79.745n 0.0v 79.755n 3.3v 84.745n 3.3v 84.755n 0.0v 89.745n 0.0v 89.755n 3.3v 94.745n 3.3v 94.755n 3.3v 99.745n 3.3v 99.755n 3.3v 104.745n 3.3v 104.755n 0.0v 109.745n 0.0v 109.755n 3.3v 114.745n 3.3v 114.755n 0.0v 119.745n 0.0v 119.755n 3.3v 124.745n 3.3v 124.755n 3.3v 129.745n 3.3v 129.755n 3.3v 134.745n 3.3v 134.755n 3.3v 139.745n 3.3v 139.755n 3.3v 144.745n 3.3v 144.755n 3.3v 149.745n 3.3v 149.755n 3.3v 154.745n 3.3v 154.755n 3.3v 159.745n 3.3v 159.755n 3.3v 164.745n 3.3v 164.755n 3.3v 169.745n 3.3v 169.755n 3.3v 174.745n 3.3v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 3.3v 194.745n 3.3v 194.755n 3.3v 199.745n 3.3v 199.755n 3.3v 204.745n 3.3v 204.755n 3.3v 209.745n 3.3v 209.755n 3.3v 214.745n 3.3v 214.755n 3.3v 219.745n 3.3v 219.755n 3.3v 224.745n 3.3v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 3.3v 239.745n 3.3v 239.755n 3.3v 244.745n 3.3v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 3.3v 264.745n 3.3v 264.755n 3.3v 269.745n 3.3v 269.755n 3.3v 274.745n 3.3v 274.755n 3.3v 279.745n 3.3v 279.755n 0.0v 284.745n 0.0v 284.755n 3.3v 289.745n 3.3v 289.755n 3.3v 294.745n 3.3v 294.755n 3.3v 299.745n 3.3v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 3.3v 314.745n 3.3v 314.755n 3.3v 319.745n 3.3v 319.755n 3.3v 324.745n 3.3v 324.755n 3.3v 329.745n 3.3v 329.755n 3.3v 334.745n 3.3v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 3.3v 349.745n 3.3v 349.755n 3.3v 354.745n 3.3v 354.755n 3.3v 359.745n 3.3v 359.755n 0.0v 364.745n 0.0v 364.755n 3.3v 369.745n 3.3v 369.755n 3.3v 374.745n 3.3v 374.755n 3.3v 379.745n 3.3v 379.755n 3.3v 384.745n 3.3v 384.755n 3.3v 389.745n 3.3v 389.755n 3.3v 394.745n 3.3v 394.755n 3.3v 399.745n 3.3v 399.755n 3.3v 404.745n 3.3v 404.755n 3.3v 409.745n 3.3v 409.755n 3.3v 414.745n 3.3v 414.755n 0.0v 419.745n 0.0v 419.755n 3.3v 424.745n 3.3v 424.755n 3.3v 429.745n 3.3v 429.755n 3.3v 434.745n 3.3v 434.755n 3.3v 439.745n 3.3v 439.755n 3.3v 444.745n 3.3v 444.755n 3.3v 449.745n 3.3v 449.755n 0.0v 454.745n 0.0v 454.755n 3.3v 459.745n 3.3v 459.755n 3.3v 464.745n 3.3v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 3.3v 479.745n 3.3v 479.755n 3.3v 484.745n 3.3v 484.755n 0.0v 489.745n 0.0v 489.755n 3.3v 494.745n 3.3v 494.755n 3.3v 499.745n 3.3v 499.755n 3.3v 504.745n 3.3v 504.755n 0.0v 509.745n 0.0v 509.755n 3.3v 514.745n 3.3v 514.755n 3.3v 519.745n 3.3v 519.755n 3.3v 524.745n 3.3v 524.755n 3.3v 529.745n 3.3v 529.755n 0.0v 534.745n 0.0v 534.755n 3.3v 539.745n 3.3v 539.755n 3.3v 544.745n 3.3v 544.755n 0.0v 549.745n 0.0v 549.755n 3.3v 554.745n 3.3v 554.755n 3.3v 559.745n 3.3v 559.755n 0.0v 564.745n 0.0v 564.755n 3.3v 569.745n 3.3v 569.755n 3.3v 574.745n 3.3v 574.755n 3.3v 579.745n 3.3v 579.755n 3.3v 584.745n 3.3v 584.755n 3.3v 589.745n 3.3v 589.755n 3.3v 594.745n 3.3v 594.755n 3.3v 599.745n 3.3v 599.755n 3.3v 604.745n 3.3v 604.755n 3.3v 609.745n 3.3v 609.755n 3.3v 614.745n 3.3v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 3.3v 629.745n 3.3v 629.755n 3.3v 634.745n 3.3v 634.755n 3.3v 639.745n 3.3v 639.755n 0.0v 644.745n 0.0v 644.755n 3.3v 649.745n 3.3v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 3.3v 664.745n 3.3v 664.755n 3.3v 669.745n 3.3v 669.755n 3.3v 674.745n 3.3v 674.755n 3.3v 679.745n 3.3v 679.755n 3.3v 684.745n 3.3v 684.755n 0.0v 689.745n 0.0v 689.755n 3.3v 694.745n 3.3v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 3.3v 709.745n 3.3v 709.755n 0.0v 714.745n 0.0v 714.755n 3.3v 719.745n 3.3v 719.755n 0.0v 724.745n 0.0v 724.755n 3.3v 729.745n 3.3v 729.755n 3.3v 734.745n 3.3v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 3.3v 754.745n 3.3v 754.755n 3.3v 759.745n 3.3v 759.755n 3.3v 764.745n 3.3v 764.755n 3.3v 769.745n 3.3v 769.755n 3.3v 774.745n 3.3v 774.755n 0.0v 779.745n 0.0v 779.755n 3.3v 784.745n 3.3v 784.755n 3.3v 789.745n 3.3v 789.755n 3.3v 794.745n 3.3v 794.755n 3.3v 799.745n 3.3v 799.755n 3.3v 804.745n 3.3v 804.755n 3.3v 809.745n 3.3v 809.755n 0.0v 814.745n 0.0v 814.755n 3.3v 819.745n 3.3v 819.755n 0.0v 824.745n 0.0v 824.755n 3.3v 829.745n 3.3v 829.755n 0.0v 834.745n 0.0v 834.755n 3.3v 839.745n 3.3v 839.755n 3.3v 844.745n 3.3v 844.755n 3.3v 849.745n 3.3v 849.755n 3.3v 854.745n 3.3v 854.755n 3.3v 859.745n 3.3v 859.755n 3.3v 864.745n 3.3v 864.755n 0.0v 869.745n 0.0v 869.755n 3.3v 874.745n 3.3v 874.755n 3.3v 879.745n 3.3v 879.755n 3.3v 884.745n 3.3v 884.755n 3.3v 889.745n 3.3v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 3.3v 904.745n 3.3v 904.755n 3.3v 909.745n 3.3v 909.755n 3.3v 914.745n 3.3v 914.755n 3.3v 919.745n 3.3v 919.755n 3.3v 924.745n 3.3v 924.755n 3.3v 929.745n 3.3v 929.755n 3.3v 934.745n 3.3v 934.755n 3.3v 939.745n 3.3v 939.755n 3.3v 944.745n 3.3v 944.755n 3.3v 949.745n 3.3v 949.755n 3.3v 954.745n 3.3v 954.755n 3.3v 959.745n 3.3v 959.755n 0.0v 964.745n 0.0v 964.755n 3.3v 969.745n 3.3v 969.755n 3.3v 974.745n 3.3v 974.755n 3.3v 979.745n 3.3v 979.755n 0.0v 984.745n 0.0v 984.755n 3.3v 989.745n 3.3v 989.755n 3.3v 994.745n 3.3v 994.755n 3.3v 999.745n 3.3v 999.755n 3.3v 1004.745n 3.3v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 3.3v 1024.745n 3.3v 1024.755n 3.3v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 3.3 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 vdout0_0ck4 = 3.3 time = 25
* CHECK dout0_1 vdout0_1ck4 = 3.3 time = 25
* CHECK dout0_2 vdout0_2ck4 = 0 time = 25
* CHECK dout0_3 vdout0_3ck4 = 3.3 time = 25
* CHECK dout0_4 vdout0_4ck4 = 0 time = 25
* CHECK dout0_5 vdout0_5ck4 = 0 time = 25
* CHECK dout0_6 vdout0_6ck4 = 0 time = 25
* CHECK dout0_7 vdout0_7ck4 = 3.3 time = 25
* CHECK dout0_8 vdout0_8ck4 = 0 time = 25
* CHECK dout0_9 vdout0_9ck4 = 3.3 time = 25
* CHECK dout0_10 vdout0_10ck4 = 0 time = 25
* CHECK dout0_11 vdout0_11ck4 = 3.3 time = 25
* CHECK dout0_12 vdout0_12ck4 = 3.3 time = 25
* CHECK dout0_13 vdout0_13ck4 = 3.3 time = 25
* CHECK dout0_14 vdout0_14ck4 = 3.3 time = 25
* CHECK dout0_15 vdout0_15ck4 = 0 time = 25
* CHECK dout0_16 vdout0_16ck4 = 3.3 time = 25
* CHECK dout0_17 vdout0_17ck4 = 0 time = 25
* CHECK dout0_18 vdout0_18ck4 = 0 time = 25
* CHECK dout0_19 vdout0_19ck4 = 3.3 time = 25
* CHECK dout0_20 vdout0_20ck4 = 3.3 time = 25
* CHECK dout0_21 vdout0_21ck4 = 3.3 time = 25
* CHECK dout0_22 vdout0_22ck4 = 3.3 time = 25
* CHECK dout0_23 vdout0_23ck4 = 0 time = 25
* CHECK dout0_24 vdout0_24ck4 = 0 time = 25
* CHECK dout0_25 vdout0_25ck4 = 3.3 time = 25
* CHECK dout0_26 vdout0_26ck4 = 3.3 time = 25
* CHECK dout0_27 vdout0_27ck4 = 0 time = 25
* CHECK dout0_28 vdout0_28ck4 = 3.3 time = 25
* CHECK dout0_29 vdout0_29ck4 = 3.3 time = 25
* CHECK dout0_30 vdout0_30ck4 = 3.3 time = 25
* CHECK dout0_31 vdout0_31ck4 = 0 time = 25
* CHECK dout0_0 vdout0_0ck7 = 0 time = 40
* CHECK dout0_1 vdout0_1ck7 = 0 time = 40
* CHECK dout0_2 vdout0_2ck7 = 0 time = 40
* CHECK dout0_3 vdout0_3ck7 = 0 time = 40
* CHECK dout0_4 vdout0_4ck7 = 0 time = 40
* CHECK dout0_5 vdout0_5ck7 = 3.3 time = 40
* CHECK dout0_6 vdout0_6ck7 = 0 time = 40
* CHECK dout0_7 vdout0_7ck7 = 3.3 time = 40
* CHECK dout0_8 vdout0_8ck7 = 3.3 time = 40
* CHECK dout0_9 vdout0_9ck7 = 3.3 time = 40
* CHECK dout0_10 vdout0_10ck7 = 3.3 time = 40
* CHECK dout0_11 vdout0_11ck7 = 3.3 time = 40
* CHECK dout0_12 vdout0_12ck7 = 3.3 time = 40
* CHECK dout0_13 vdout0_13ck7 = 0 time = 40
* CHECK dout0_14 vdout0_14ck7 = 0 time = 40
* CHECK dout0_15 vdout0_15ck7 = 0 time = 40
* CHECK dout0_16 vdout0_16ck7 = 0 time = 40
* CHECK dout0_17 vdout0_17ck7 = 3.3 time = 40
* CHECK dout0_18 vdout0_18ck7 = 0 time = 40
* CHECK dout0_19 vdout0_19ck7 = 3.3 time = 40
* CHECK dout0_20 vdout0_20ck7 = 3.3 time = 40
* CHECK dout0_21 vdout0_21ck7 = 3.3 time = 40
* CHECK dout0_22 vdout0_22ck7 = 3.3 time = 40
* CHECK dout0_23 vdout0_23ck7 = 3.3 time = 40
* CHECK dout0_24 vdout0_24ck7 = 3.3 time = 40
* CHECK dout0_25 vdout0_25ck7 = 3.3 time = 40
* CHECK dout0_26 vdout0_26ck7 = 3.3 time = 40
* CHECK dout0_27 vdout0_27ck7 = 3.3 time = 40
* CHECK dout0_28 vdout0_28ck7 = 0 time = 40
* CHECK dout0_29 vdout0_29ck7 = 0 time = 40
* CHECK dout0_30 vdout0_30ck7 = 3.3 time = 40
* CHECK dout0_31 vdout0_31ck7 = 0 time = 40
* CHECK dout0_0 vdout0_0ck11 = 0 time = 60
* CHECK dout0_1 vdout0_1ck11 = 3.3 time = 60
* CHECK dout0_2 vdout0_2ck11 = 0 time = 60
* CHECK dout0_3 vdout0_3ck11 = 0 time = 60
* CHECK dout0_4 vdout0_4ck11 = 0 time = 60
* CHECK dout0_5 vdout0_5ck11 = 3.3 time = 60
* CHECK dout0_6 vdout0_6ck11 = 3.3 time = 60
* CHECK dout0_7 vdout0_7ck11 = 3.3 time = 60
* CHECK dout0_8 vdout0_8ck11 = 3.3 time = 60
* CHECK dout0_9 vdout0_9ck11 = 3.3 time = 60
* CHECK dout0_10 vdout0_10ck11 = 0 time = 60
* CHECK dout0_11 vdout0_11ck11 = 0 time = 60
* CHECK dout0_12 vdout0_12ck11 = 3.3 time = 60
* CHECK dout0_13 vdout0_13ck11 = 0 time = 60
* CHECK dout0_14 vdout0_14ck11 = 3.3 time = 60
* CHECK dout0_15 vdout0_15ck11 = 0 time = 60
* CHECK dout0_16 vdout0_16ck11 = 3.3 time = 60
* CHECK dout0_17 vdout0_17ck11 = 0 time = 60
* CHECK dout0_18 vdout0_18ck11 = 0 time = 60
* CHECK dout0_19 vdout0_19ck11 = 0 time = 60
* CHECK dout0_20 vdout0_20ck11 = 0 time = 60
* CHECK dout0_21 vdout0_21ck11 = 0 time = 60
* CHECK dout0_22 vdout0_22ck11 = 3.3 time = 60
* CHECK dout0_23 vdout0_23ck11 = 3.3 time = 60
* CHECK dout0_24 vdout0_24ck11 = 0 time = 60
* CHECK dout0_25 vdout0_25ck11 = 3.3 time = 60
* CHECK dout0_26 vdout0_26ck11 = 3.3 time = 60
* CHECK dout0_27 vdout0_27ck11 = 3.3 time = 60
* CHECK dout0_28 vdout0_28ck11 = 3.3 time = 60
* CHECK dout0_29 vdout0_29ck11 = 0 time = 60
* CHECK dout0_30 vdout0_30ck11 = 3.3 time = 60
* CHECK dout0_31 vdout0_31ck11 = 0 time = 60
* CHECK dout0_0 vdout0_0ck12 = 0 time = 65
* CHECK dout0_1 vdout0_1ck12 = 3.3 time = 65
* CHECK dout0_2 vdout0_2ck12 = 0 time = 65
* CHECK dout0_3 vdout0_3ck12 = 0 time = 65
* CHECK dout0_4 vdout0_4ck12 = 0 time = 65
* CHECK dout0_5 vdout0_5ck12 = 3.3 time = 65
* CHECK dout0_6 vdout0_6ck12 = 3.3 time = 65
* CHECK dout0_7 vdout0_7ck12 = 3.3 time = 65
* CHECK dout0_8 vdout0_8ck12 = 3.3 time = 65
* CHECK dout0_9 vdout0_9ck12 = 3.3 time = 65
* CHECK dout0_10 vdout0_10ck12 = 0 time = 65
* CHECK dout0_11 vdout0_11ck12 = 0 time = 65
* CHECK dout0_12 vdout0_12ck12 = 3.3 time = 65
* CHECK dout0_13 vdout0_13ck12 = 0 time = 65
* CHECK dout0_14 vdout0_14ck12 = 3.3 time = 65
* CHECK dout0_15 vdout0_15ck12 = 0 time = 65
* CHECK dout0_16 vdout0_16ck12 = 3.3 time = 65
* CHECK dout0_17 vdout0_17ck12 = 0 time = 65
* CHECK dout0_18 vdout0_18ck12 = 0 time = 65
* CHECK dout0_19 vdout0_19ck12 = 0 time = 65
* CHECK dout0_20 vdout0_20ck12 = 0 time = 65
* CHECK dout0_21 vdout0_21ck12 = 0 time = 65
* CHECK dout0_22 vdout0_22ck12 = 3.3 time = 65
* CHECK dout0_23 vdout0_23ck12 = 3.3 time = 65
* CHECK dout0_24 vdout0_24ck12 = 0 time = 65
* CHECK dout0_25 vdout0_25ck12 = 3.3 time = 65
* CHECK dout0_26 vdout0_26ck12 = 3.3 time = 65
* CHECK dout0_27 vdout0_27ck12 = 3.3 time = 65
* CHECK dout0_28 vdout0_28ck12 = 3.3 time = 65
* CHECK dout0_29 vdout0_29ck12 = 0 time = 65
* CHECK dout0_30 vdout0_30ck12 = 3.3 time = 65
* CHECK dout0_31 vdout0_31ck12 = 0 time = 65
* CHECK dout0_0 vdout0_0ck13 = 0 time = 70
* CHECK dout0_1 vdout0_1ck13 = 3.3 time = 70
* CHECK dout0_2 vdout0_2ck13 = 0 time = 70
* CHECK dout0_3 vdout0_3ck13 = 0 time = 70
* CHECK dout0_4 vdout0_4ck13 = 0 time = 70
* CHECK dout0_5 vdout0_5ck13 = 3.3 time = 70
* CHECK dout0_6 vdout0_6ck13 = 3.3 time = 70
* CHECK dout0_7 vdout0_7ck13 = 3.3 time = 70
* CHECK dout0_8 vdout0_8ck13 = 3.3 time = 70
* CHECK dout0_9 vdout0_9ck13 = 3.3 time = 70
* CHECK dout0_10 vdout0_10ck13 = 0 time = 70
* CHECK dout0_11 vdout0_11ck13 = 0 time = 70
* CHECK dout0_12 vdout0_12ck13 = 3.3 time = 70
* CHECK dout0_13 vdout0_13ck13 = 0 time = 70
* CHECK dout0_14 vdout0_14ck13 = 3.3 time = 70
* CHECK dout0_15 vdout0_15ck13 = 0 time = 70
* CHECK dout0_16 vdout0_16ck13 = 3.3 time = 70
* CHECK dout0_17 vdout0_17ck13 = 0 time = 70
* CHECK dout0_18 vdout0_18ck13 = 0 time = 70
* CHECK dout0_19 vdout0_19ck13 = 0 time = 70
* CHECK dout0_20 vdout0_20ck13 = 0 time = 70
* CHECK dout0_21 vdout0_21ck13 = 0 time = 70
* CHECK dout0_22 vdout0_22ck13 = 3.3 time = 70
* CHECK dout0_23 vdout0_23ck13 = 3.3 time = 70
* CHECK dout0_24 vdout0_24ck13 = 0 time = 70
* CHECK dout0_25 vdout0_25ck13 = 3.3 time = 70
* CHECK dout0_26 vdout0_26ck13 = 3.3 time = 70
* CHECK dout0_27 vdout0_27ck13 = 3.3 time = 70
* CHECK dout0_28 vdout0_28ck13 = 3.3 time = 70
* CHECK dout0_29 vdout0_29ck13 = 0 time = 70
* CHECK dout0_30 vdout0_30ck13 = 3.3 time = 70
* CHECK dout0_31 vdout0_31ck13 = 0 time = 70
* CHECK dout0_0 vdout0_0ck14 = 3.3 time = 75
* CHECK dout0_1 vdout0_1ck14 = 3.3 time = 75
* CHECK dout0_2 vdout0_2ck14 = 3.3 time = 75
* CHECK dout0_3 vdout0_3ck14 = 3.3 time = 75
* CHECK dout0_4 vdout0_4ck14 = 3.3 time = 75
* CHECK dout0_5 vdout0_5ck14 = 3.3 time = 75
* CHECK dout0_6 vdout0_6ck14 = 3.3 time = 75
* CHECK dout0_7 vdout0_7ck14 = 0 time = 75
* CHECK dout0_8 vdout0_8ck14 = 0 time = 75
* CHECK dout0_9 vdout0_9ck14 = 3.3 time = 75
* CHECK dout0_10 vdout0_10ck14 = 0 time = 75
* CHECK dout0_11 vdout0_11ck14 = 3.3 time = 75
* CHECK dout0_12 vdout0_12ck14 = 0 time = 75
* CHECK dout0_13 vdout0_13ck14 = 3.3 time = 75
* CHECK dout0_14 vdout0_14ck14 = 0 time = 75
* CHECK dout0_15 vdout0_15ck14 = 0 time = 75
* CHECK dout0_16 vdout0_16ck14 = 3.3 time = 75
* CHECK dout0_17 vdout0_17ck14 = 0 time = 75
* CHECK dout0_18 vdout0_18ck14 = 0 time = 75
* CHECK dout0_19 vdout0_19ck14 = 3.3 time = 75
* CHECK dout0_20 vdout0_20ck14 = 0 time = 75
* CHECK dout0_21 vdout0_21ck14 = 3.3 time = 75
* CHECK dout0_22 vdout0_22ck14 = 0 time = 75
* CHECK dout0_23 vdout0_23ck14 = 3.3 time = 75
* CHECK dout0_24 vdout0_24ck14 = 0 time = 75
* CHECK dout0_25 vdout0_25ck14 = 0 time = 75
* CHECK dout0_26 vdout0_26ck14 = 0 time = 75
* CHECK dout0_27 vdout0_27ck14 = 3.3 time = 75
* CHECK dout0_28 vdout0_28ck14 = 0 time = 75
* CHECK dout0_29 vdout0_29ck14 = 0 time = 75
* CHECK dout0_30 vdout0_30ck14 = 0 time = 75
* CHECK dout0_31 vdout0_31ck14 = 0 time = 75
* CHECK dout0_0 vdout0_0ck16 = 0 time = 85
* CHECK dout0_1 vdout0_1ck16 = 3.3 time = 85
* CHECK dout0_2 vdout0_2ck16 = 0 time = 85
* CHECK dout0_3 vdout0_3ck16 = 0 time = 85
* CHECK dout0_4 vdout0_4ck16 = 0 time = 85
* CHECK dout0_5 vdout0_5ck16 = 3.3 time = 85
* CHECK dout0_6 vdout0_6ck16 = 3.3 time = 85
* CHECK dout0_7 vdout0_7ck16 = 3.3 time = 85
* CHECK dout0_8 vdout0_8ck16 = 3.3 time = 85
* CHECK dout0_9 vdout0_9ck16 = 3.3 time = 85
* CHECK dout0_10 vdout0_10ck16 = 0 time = 85
* CHECK dout0_11 vdout0_11ck16 = 0 time = 85
* CHECK dout0_12 vdout0_12ck16 = 3.3 time = 85
* CHECK dout0_13 vdout0_13ck16 = 0 time = 85
* CHECK dout0_14 vdout0_14ck16 = 3.3 time = 85
* CHECK dout0_15 vdout0_15ck16 = 0 time = 85
* CHECK dout0_16 vdout0_16ck16 = 3.3 time = 85
* CHECK dout0_17 vdout0_17ck16 = 0 time = 85
* CHECK dout0_18 vdout0_18ck16 = 0 time = 85
* CHECK dout0_19 vdout0_19ck16 = 0 time = 85
* CHECK dout0_20 vdout0_20ck16 = 0 time = 85
* CHECK dout0_21 vdout0_21ck16 = 0 time = 85
* CHECK dout0_22 vdout0_22ck16 = 3.3 time = 85
* CHECK dout0_23 vdout0_23ck16 = 3.3 time = 85
* CHECK dout0_24 vdout0_24ck16 = 0 time = 85
* CHECK dout0_25 vdout0_25ck16 = 3.3 time = 85
* CHECK dout0_26 vdout0_26ck16 = 3.3 time = 85
* CHECK dout0_27 vdout0_27ck16 = 3.3 time = 85
* CHECK dout0_28 vdout0_28ck16 = 3.3 time = 85
* CHECK dout0_29 vdout0_29ck16 = 0 time = 85
* CHECK dout0_30 vdout0_30ck16 = 3.3 time = 85
* CHECK dout0_31 vdout0_31ck16 = 0 time = 85
* CHECK dout0_0 vdout0_0ck18 = 3.3 time = 95
* CHECK dout0_1 vdout0_1ck18 = 3.3 time = 95
* CHECK dout0_2 vdout0_2ck18 = 3.3 time = 95
* CHECK dout0_3 vdout0_3ck18 = 3.3 time = 95
* CHECK dout0_4 vdout0_4ck18 = 0 time = 95
* CHECK dout0_5 vdout0_5ck18 = 0 time = 95
* CHECK dout0_6 vdout0_6ck18 = 3.3 time = 95
* CHECK dout0_7 vdout0_7ck18 = 0 time = 95
* CHECK dout0_8 vdout0_8ck18 = 3.3 time = 95
* CHECK dout0_9 vdout0_9ck18 = 0 time = 95
* CHECK dout0_10 vdout0_10ck18 = 0 time = 95
* CHECK dout0_11 vdout0_11ck18 = 0 time = 95
* CHECK dout0_12 vdout0_12ck18 = 3.3 time = 95
* CHECK dout0_13 vdout0_13ck18 = 3.3 time = 95
* CHECK dout0_14 vdout0_14ck18 = 0 time = 95
* CHECK dout0_15 vdout0_15ck18 = 0 time = 95
* CHECK dout0_16 vdout0_16ck18 = 3.3 time = 95
* CHECK dout0_17 vdout0_17ck18 = 0 time = 95
* CHECK dout0_18 vdout0_18ck18 = 3.3 time = 95
* CHECK dout0_19 vdout0_19ck18 = 0 time = 95
* CHECK dout0_20 vdout0_20ck18 = 3.3 time = 95
* CHECK dout0_21 vdout0_21ck18 = 3.3 time = 95
* CHECK dout0_22 vdout0_22ck18 = 3.3 time = 95
* CHECK dout0_23 vdout0_23ck18 = 0 time = 95
* CHECK dout0_24 vdout0_24ck18 = 3.3 time = 95
* CHECK dout0_25 vdout0_25ck18 = 3.3 time = 95
* CHECK dout0_26 vdout0_26ck18 = 0 time = 95
* CHECK dout0_27 vdout0_27ck18 = 3.3 time = 95
* CHECK dout0_28 vdout0_28ck18 = 3.3 time = 95
* CHECK dout0_29 vdout0_29ck18 = 3.3 time = 95
* CHECK dout0_30 vdout0_30ck18 = 3.3 time = 95
* CHECK dout0_31 vdout0_31ck18 = 3.3 time = 95
* CHECK dout0_0 vdout0_0ck19 = 3.3 time = 100
* CHECK dout0_1 vdout0_1ck19 = 3.3 time = 100
* CHECK dout0_2 vdout0_2ck19 = 3.3 time = 100
* CHECK dout0_3 vdout0_3ck19 = 3.3 time = 100
* CHECK dout0_4 vdout0_4ck19 = 0 time = 100
* CHECK dout0_5 vdout0_5ck19 = 0 time = 100
* CHECK dout0_6 vdout0_6ck19 = 3.3 time = 100
* CHECK dout0_7 vdout0_7ck19 = 0 time = 100
* CHECK dout0_8 vdout0_8ck19 = 3.3 time = 100
* CHECK dout0_9 vdout0_9ck19 = 0 time = 100
* CHECK dout0_10 vdout0_10ck19 = 0 time = 100
* CHECK dout0_11 vdout0_11ck19 = 0 time = 100
* CHECK dout0_12 vdout0_12ck19 = 3.3 time = 100
* CHECK dout0_13 vdout0_13ck19 = 3.3 time = 100
* CHECK dout0_14 vdout0_14ck19 = 0 time = 100
* CHECK dout0_15 vdout0_15ck19 = 0 time = 100
* CHECK dout0_16 vdout0_16ck19 = 3.3 time = 100
* CHECK dout0_17 vdout0_17ck19 = 0 time = 100
* CHECK dout0_18 vdout0_18ck19 = 3.3 time = 100
* CHECK dout0_19 vdout0_19ck19 = 0 time = 100
* CHECK dout0_20 vdout0_20ck19 = 3.3 time = 100
* CHECK dout0_21 vdout0_21ck19 = 3.3 time = 100
* CHECK dout0_22 vdout0_22ck19 = 3.3 time = 100
* CHECK dout0_23 vdout0_23ck19 = 0 time = 100
* CHECK dout0_24 vdout0_24ck19 = 3.3 time = 100
* CHECK dout0_25 vdout0_25ck19 = 3.3 time = 100
* CHECK dout0_26 vdout0_26ck19 = 0 time = 100
* CHECK dout0_27 vdout0_27ck19 = 3.3 time = 100
* CHECK dout0_28 vdout0_28ck19 = 3.3 time = 100
* CHECK dout0_29 vdout0_29ck19 = 3.3 time = 100
* CHECK dout0_30 vdout0_30ck19 = 3.3 time = 100
* CHECK dout0_31 vdout0_31ck19 = 3.3 time = 100
* CHECK dout0_0 vdout0_0ck20 = 3.3 time = 105
* CHECK dout0_1 vdout0_1ck20 = 3.3 time = 105
* CHECK dout0_2 vdout0_2ck20 = 3.3 time = 105
* CHECK dout0_3 vdout0_3ck20 = 3.3 time = 105
* CHECK dout0_4 vdout0_4ck20 = 0 time = 105
* CHECK dout0_5 vdout0_5ck20 = 0 time = 105
* CHECK dout0_6 vdout0_6ck20 = 3.3 time = 105
* CHECK dout0_7 vdout0_7ck20 = 0 time = 105
* CHECK dout0_8 vdout0_8ck20 = 3.3 time = 105
* CHECK dout0_9 vdout0_9ck20 = 0 time = 105
* CHECK dout0_10 vdout0_10ck20 = 0 time = 105
* CHECK dout0_11 vdout0_11ck20 = 0 time = 105
* CHECK dout0_12 vdout0_12ck20 = 3.3 time = 105
* CHECK dout0_13 vdout0_13ck20 = 3.3 time = 105
* CHECK dout0_14 vdout0_14ck20 = 0 time = 105
* CHECK dout0_15 vdout0_15ck20 = 0 time = 105
* CHECK dout0_16 vdout0_16ck20 = 3.3 time = 105
* CHECK dout0_17 vdout0_17ck20 = 0 time = 105
* CHECK dout0_18 vdout0_18ck20 = 3.3 time = 105
* CHECK dout0_19 vdout0_19ck20 = 0 time = 105
* CHECK dout0_20 vdout0_20ck20 = 3.3 time = 105
* CHECK dout0_21 vdout0_21ck20 = 3.3 time = 105
* CHECK dout0_22 vdout0_22ck20 = 3.3 time = 105
* CHECK dout0_23 vdout0_23ck20 = 0 time = 105
* CHECK dout0_24 vdout0_24ck20 = 3.3 time = 105
* CHECK dout0_25 vdout0_25ck20 = 3.3 time = 105
* CHECK dout0_26 vdout0_26ck20 = 0 time = 105
* CHECK dout0_27 vdout0_27ck20 = 3.3 time = 105
* CHECK dout0_28 vdout0_28ck20 = 3.3 time = 105
* CHECK dout0_29 vdout0_29ck20 = 3.3 time = 105
* CHECK dout0_30 vdout0_30ck20 = 3.3 time = 105
* CHECK dout0_31 vdout0_31ck20 = 3.3 time = 105
* CHECK dout0_0 vdout0_0ck22 = 0 time = 115
* CHECK dout0_1 vdout0_1ck22 = 3.3 time = 115
* CHECK dout0_2 vdout0_2ck22 = 0 time = 115
* CHECK dout0_3 vdout0_3ck22 = 3.3 time = 115
* CHECK dout0_4 vdout0_4ck22 = 3.3 time = 115
* CHECK dout0_5 vdout0_5ck22 = 0 time = 115
* CHECK dout0_6 vdout0_6ck22 = 0 time = 115
* CHECK dout0_7 vdout0_7ck22 = 0 time = 115
* CHECK dout0_8 vdout0_8ck22 = 0 time = 115
* CHECK dout0_9 vdout0_9ck22 = 3.3 time = 115
* CHECK dout0_10 vdout0_10ck22 = 3.3 time = 115
* CHECK dout0_11 vdout0_11ck22 = 0 time = 115
* CHECK dout0_12 vdout0_12ck22 = 0 time = 115
* CHECK dout0_13 vdout0_13ck22 = 0 time = 115
* CHECK dout0_14 vdout0_14ck22 = 3.3 time = 115
* CHECK dout0_15 vdout0_15ck22 = 0 time = 115
* CHECK dout0_16 vdout0_16ck22 = 0 time = 115
* CHECK dout0_17 vdout0_17ck22 = 3.3 time = 115
* CHECK dout0_18 vdout0_18ck22 = 3.3 time = 115
* CHECK dout0_19 vdout0_19ck22 = 0 time = 115
* CHECK dout0_20 vdout0_20ck22 = 0 time = 115
* CHECK dout0_21 vdout0_21ck22 = 0 time = 115
* CHECK dout0_22 vdout0_22ck22 = 0 time = 115
* CHECK dout0_23 vdout0_23ck22 = 3.3 time = 115
* CHECK dout0_24 vdout0_24ck22 = 0 time = 115
* CHECK dout0_25 vdout0_25ck22 = 0 time = 115
* CHECK dout0_26 vdout0_26ck22 = 3.3 time = 115
* CHECK dout0_27 vdout0_27ck22 = 3.3 time = 115
* CHECK dout0_28 vdout0_28ck22 = 0 time = 115
* CHECK dout0_29 vdout0_29ck22 = 0 time = 115
* CHECK dout0_30 vdout0_30ck22 = 0 time = 115
* CHECK dout0_31 vdout0_31ck22 = 3.3 time = 115
* CHECK dout0_0 vdout0_0ck24 = 0 time = 125
* CHECK dout0_1 vdout0_1ck24 = 0 time = 125
* CHECK dout0_2 vdout0_2ck24 = 0 time = 125
* CHECK dout0_3 vdout0_3ck24 = 0 time = 125
* CHECK dout0_4 vdout0_4ck24 = 0 time = 125
* CHECK dout0_5 vdout0_5ck24 = 0 time = 125
* CHECK dout0_6 vdout0_6ck24 = 3.3 time = 125
* CHECK dout0_7 vdout0_7ck24 = 0 time = 125
* CHECK dout0_8 vdout0_8ck24 = 3.3 time = 125
* CHECK dout0_9 vdout0_9ck24 = 0 time = 125
* CHECK dout0_10 vdout0_10ck24 = 3.3 time = 125
* CHECK dout0_11 vdout0_11ck24 = 0 time = 125
* CHECK dout0_12 vdout0_12ck24 = 0 time = 125
* CHECK dout0_13 vdout0_13ck24 = 0 time = 125
* CHECK dout0_14 vdout0_14ck24 = 0 time = 125
* CHECK dout0_15 vdout0_15ck24 = 0 time = 125
* CHECK dout0_16 vdout0_16ck24 = 3.3 time = 125
* CHECK dout0_17 vdout0_17ck24 = 3.3 time = 125
* CHECK dout0_18 vdout0_18ck24 = 3.3 time = 125
* CHECK dout0_19 vdout0_19ck24 = 0 time = 125
* CHECK dout0_20 vdout0_20ck24 = 3.3 time = 125
* CHECK dout0_21 vdout0_21ck24 = 0 time = 125
* CHECK dout0_22 vdout0_22ck24 = 3.3 time = 125
* CHECK dout0_23 vdout0_23ck24 = 0 time = 125
* CHECK dout0_24 vdout0_24ck24 = 3.3 time = 125
* CHECK dout0_25 vdout0_25ck24 = 3.3 time = 125
* CHECK dout0_26 vdout0_26ck24 = 0 time = 125
* CHECK dout0_27 vdout0_27ck24 = 3.3 time = 125
* CHECK dout0_28 vdout0_28ck24 = 3.3 time = 125
* CHECK dout0_29 vdout0_29ck24 = 3.3 time = 125
* CHECK dout0_30 vdout0_30ck24 = 0 time = 125
* CHECK dout0_31 vdout0_31ck24 = 3.3 time = 125
* CHECK dout0_0 vdout0_0ck25 = 0 time = 130
* CHECK dout0_1 vdout0_1ck25 = 3.3 time = 130
* CHECK dout0_2 vdout0_2ck25 = 0 time = 130
* CHECK dout0_3 vdout0_3ck25 = 3.3 time = 130
* CHECK dout0_4 vdout0_4ck25 = 3.3 time = 130
* CHECK dout0_5 vdout0_5ck25 = 0 time = 130
* CHECK dout0_6 vdout0_6ck25 = 0 time = 130
* CHECK dout0_7 vdout0_7ck25 = 0 time = 130
* CHECK dout0_8 vdout0_8ck25 = 0 time = 130
* CHECK dout0_9 vdout0_9ck25 = 3.3 time = 130
* CHECK dout0_10 vdout0_10ck25 = 3.3 time = 130
* CHECK dout0_11 vdout0_11ck25 = 0 time = 130
* CHECK dout0_12 vdout0_12ck25 = 0 time = 130
* CHECK dout0_13 vdout0_13ck25 = 0 time = 130
* CHECK dout0_14 vdout0_14ck25 = 3.3 time = 130
* CHECK dout0_15 vdout0_15ck25 = 0 time = 130
* CHECK dout0_16 vdout0_16ck25 = 0 time = 130
* CHECK dout0_17 vdout0_17ck25 = 3.3 time = 130
* CHECK dout0_18 vdout0_18ck25 = 3.3 time = 130
* CHECK dout0_19 vdout0_19ck25 = 0 time = 130
* CHECK dout0_20 vdout0_20ck25 = 0 time = 130
* CHECK dout0_21 vdout0_21ck25 = 0 time = 130
* CHECK dout0_22 vdout0_22ck25 = 0 time = 130
* CHECK dout0_23 vdout0_23ck25 = 3.3 time = 130
* CHECK dout0_24 vdout0_24ck25 = 0 time = 130
* CHECK dout0_25 vdout0_25ck25 = 0 time = 130
* CHECK dout0_26 vdout0_26ck25 = 3.3 time = 130
* CHECK dout0_27 vdout0_27ck25 = 3.3 time = 130
* CHECK dout0_28 vdout0_28ck25 = 0 time = 130
* CHECK dout0_29 vdout0_29ck25 = 0 time = 130
* CHECK dout0_30 vdout0_30ck25 = 0 time = 130
* CHECK dout0_31 vdout0_31ck25 = 3.3 time = 130
* CHECK dout0_0 vdout0_0ck26 = 0 time = 135
* CHECK dout0_1 vdout0_1ck26 = 0 time = 135
* CHECK dout0_2 vdout0_2ck26 = 0 time = 135
* CHECK dout0_3 vdout0_3ck26 = 0 time = 135
* CHECK dout0_4 vdout0_4ck26 = 0 time = 135
* CHECK dout0_5 vdout0_5ck26 = 0 time = 135
* CHECK dout0_6 vdout0_6ck26 = 3.3 time = 135
* CHECK dout0_7 vdout0_7ck26 = 0 time = 135
* CHECK dout0_8 vdout0_8ck26 = 3.3 time = 135
* CHECK dout0_9 vdout0_9ck26 = 0 time = 135
* CHECK dout0_10 vdout0_10ck26 = 3.3 time = 135
* CHECK dout0_11 vdout0_11ck26 = 0 time = 135
* CHECK dout0_12 vdout0_12ck26 = 0 time = 135
* CHECK dout0_13 vdout0_13ck26 = 0 time = 135
* CHECK dout0_14 vdout0_14ck26 = 0 time = 135
* CHECK dout0_15 vdout0_15ck26 = 0 time = 135
* CHECK dout0_16 vdout0_16ck26 = 3.3 time = 135
* CHECK dout0_17 vdout0_17ck26 = 3.3 time = 135
* CHECK dout0_18 vdout0_18ck26 = 3.3 time = 135
* CHECK dout0_19 vdout0_19ck26 = 0 time = 135
* CHECK dout0_20 vdout0_20ck26 = 3.3 time = 135
* CHECK dout0_21 vdout0_21ck26 = 0 time = 135
* CHECK dout0_22 vdout0_22ck26 = 3.3 time = 135
* CHECK dout0_23 vdout0_23ck26 = 0 time = 135
* CHECK dout0_24 vdout0_24ck26 = 3.3 time = 135
* CHECK dout0_25 vdout0_25ck26 = 3.3 time = 135
* CHECK dout0_26 vdout0_26ck26 = 0 time = 135
* CHECK dout0_27 vdout0_27ck26 = 3.3 time = 135
* CHECK dout0_28 vdout0_28ck26 = 3.3 time = 135
* CHECK dout0_29 vdout0_29ck26 = 3.3 time = 135
* CHECK dout0_30 vdout0_30ck26 = 0 time = 135
* CHECK dout0_31 vdout0_31ck26 = 3.3 time = 135
* CHECK dout0_0 vdout0_0ck27 = 0 time = 140
* CHECK dout0_1 vdout0_1ck27 = 3.3 time = 140
* CHECK dout0_2 vdout0_2ck27 = 0 time = 140
* CHECK dout0_3 vdout0_3ck27 = 3.3 time = 140
* CHECK dout0_4 vdout0_4ck27 = 3.3 time = 140
* CHECK dout0_5 vdout0_5ck27 = 0 time = 140
* CHECK dout0_6 vdout0_6ck27 = 0 time = 140
* CHECK dout0_7 vdout0_7ck27 = 0 time = 140
* CHECK dout0_8 vdout0_8ck27 = 0 time = 140
* CHECK dout0_9 vdout0_9ck27 = 3.3 time = 140
* CHECK dout0_10 vdout0_10ck27 = 3.3 time = 140
* CHECK dout0_11 vdout0_11ck27 = 0 time = 140
* CHECK dout0_12 vdout0_12ck27 = 0 time = 140
* CHECK dout0_13 vdout0_13ck27 = 0 time = 140
* CHECK dout0_14 vdout0_14ck27 = 3.3 time = 140
* CHECK dout0_15 vdout0_15ck27 = 0 time = 140
* CHECK dout0_16 vdout0_16ck27 = 0 time = 140
* CHECK dout0_17 vdout0_17ck27 = 3.3 time = 140
* CHECK dout0_18 vdout0_18ck27 = 3.3 time = 140
* CHECK dout0_19 vdout0_19ck27 = 0 time = 140
* CHECK dout0_20 vdout0_20ck27 = 0 time = 140
* CHECK dout0_21 vdout0_21ck27 = 0 time = 140
* CHECK dout0_22 vdout0_22ck27 = 0 time = 140
* CHECK dout0_23 vdout0_23ck27 = 3.3 time = 140
* CHECK dout0_24 vdout0_24ck27 = 0 time = 140
* CHECK dout0_25 vdout0_25ck27 = 0 time = 140
* CHECK dout0_26 vdout0_26ck27 = 3.3 time = 140
* CHECK dout0_27 vdout0_27ck27 = 3.3 time = 140
* CHECK dout0_28 vdout0_28ck27 = 0 time = 140
* CHECK dout0_29 vdout0_29ck27 = 0 time = 140
* CHECK dout0_30 vdout0_30ck27 = 0 time = 140
* CHECK dout0_31 vdout0_31ck27 = 3.3 time = 140
* CHECK dout0_0 vdout0_0ck28 = 0 time = 145
* CHECK dout0_1 vdout0_1ck28 = 3.3 time = 145
* CHECK dout0_2 vdout0_2ck28 = 0 time = 145
* CHECK dout0_3 vdout0_3ck28 = 3.3 time = 145
* CHECK dout0_4 vdout0_4ck28 = 3.3 time = 145
* CHECK dout0_5 vdout0_5ck28 = 0 time = 145
* CHECK dout0_6 vdout0_6ck28 = 0 time = 145
* CHECK dout0_7 vdout0_7ck28 = 0 time = 145
* CHECK dout0_8 vdout0_8ck28 = 0 time = 145
* CHECK dout0_9 vdout0_9ck28 = 3.3 time = 145
* CHECK dout0_10 vdout0_10ck28 = 3.3 time = 145
* CHECK dout0_11 vdout0_11ck28 = 0 time = 145
* CHECK dout0_12 vdout0_12ck28 = 0 time = 145
* CHECK dout0_13 vdout0_13ck28 = 0 time = 145
* CHECK dout0_14 vdout0_14ck28 = 3.3 time = 145
* CHECK dout0_15 vdout0_15ck28 = 0 time = 145
* CHECK dout0_16 vdout0_16ck28 = 0 time = 145
* CHECK dout0_17 vdout0_17ck28 = 3.3 time = 145
* CHECK dout0_18 vdout0_18ck28 = 3.3 time = 145
* CHECK dout0_19 vdout0_19ck28 = 0 time = 145
* CHECK dout0_20 vdout0_20ck28 = 0 time = 145
* CHECK dout0_21 vdout0_21ck28 = 0 time = 145
* CHECK dout0_22 vdout0_22ck28 = 0 time = 145
* CHECK dout0_23 vdout0_23ck28 = 3.3 time = 145
* CHECK dout0_24 vdout0_24ck28 = 0 time = 145
* CHECK dout0_25 vdout0_25ck28 = 0 time = 145
* CHECK dout0_26 vdout0_26ck28 = 3.3 time = 145
* CHECK dout0_27 vdout0_27ck28 = 3.3 time = 145
* CHECK dout0_28 vdout0_28ck28 = 0 time = 145
* CHECK dout0_29 vdout0_29ck28 = 0 time = 145
* CHECK dout0_30 vdout0_30ck28 = 0 time = 145
* CHECK dout0_31 vdout0_31ck28 = 3.3 time = 145
* CHECK dout0_0 vdout0_0ck29 = 0 time = 150
* CHECK dout0_1 vdout0_1ck29 = 3.3 time = 150
* CHECK dout0_2 vdout0_2ck29 = 0 time = 150
* CHECK dout0_3 vdout0_3ck29 = 3.3 time = 150
* CHECK dout0_4 vdout0_4ck29 = 3.3 time = 150
* CHECK dout0_5 vdout0_5ck29 = 0 time = 150
* CHECK dout0_6 vdout0_6ck29 = 0 time = 150
* CHECK dout0_7 vdout0_7ck29 = 0 time = 150
* CHECK dout0_8 vdout0_8ck29 = 0 time = 150
* CHECK dout0_9 vdout0_9ck29 = 3.3 time = 150
* CHECK dout0_10 vdout0_10ck29 = 3.3 time = 150
* CHECK dout0_11 vdout0_11ck29 = 0 time = 150
* CHECK dout0_12 vdout0_12ck29 = 0 time = 150
* CHECK dout0_13 vdout0_13ck29 = 0 time = 150
* CHECK dout0_14 vdout0_14ck29 = 3.3 time = 150
* CHECK dout0_15 vdout0_15ck29 = 0 time = 150
* CHECK dout0_16 vdout0_16ck29 = 0 time = 150
* CHECK dout0_17 vdout0_17ck29 = 3.3 time = 150
* CHECK dout0_18 vdout0_18ck29 = 3.3 time = 150
* CHECK dout0_19 vdout0_19ck29 = 0 time = 150
* CHECK dout0_20 vdout0_20ck29 = 0 time = 150
* CHECK dout0_21 vdout0_21ck29 = 0 time = 150
* CHECK dout0_22 vdout0_22ck29 = 0 time = 150
* CHECK dout0_23 vdout0_23ck29 = 3.3 time = 150
* CHECK dout0_24 vdout0_24ck29 = 0 time = 150
* CHECK dout0_25 vdout0_25ck29 = 0 time = 150
* CHECK dout0_26 vdout0_26ck29 = 3.3 time = 150
* CHECK dout0_27 vdout0_27ck29 = 3.3 time = 150
* CHECK dout0_28 vdout0_28ck29 = 0 time = 150
* CHECK dout0_29 vdout0_29ck29 = 0 time = 150
* CHECK dout0_30 vdout0_30ck29 = 0 time = 150
* CHECK dout0_31 vdout0_31ck29 = 3.3 time = 150
* CHECK dout0_0 vdout0_0ck30 = 0 time = 155
* CHECK dout0_1 vdout0_1ck30 = 0 time = 155
* CHECK dout0_2 vdout0_2ck30 = 0 time = 155
* CHECK dout0_3 vdout0_3ck30 = 0 time = 155
* CHECK dout0_4 vdout0_4ck30 = 0 time = 155
* CHECK dout0_5 vdout0_5ck30 = 0 time = 155
* CHECK dout0_6 vdout0_6ck30 = 3.3 time = 155
* CHECK dout0_7 vdout0_7ck30 = 0 time = 155
* CHECK dout0_8 vdout0_8ck30 = 3.3 time = 155
* CHECK dout0_9 vdout0_9ck30 = 0 time = 155
* CHECK dout0_10 vdout0_10ck30 = 3.3 time = 155
* CHECK dout0_11 vdout0_11ck30 = 0 time = 155
* CHECK dout0_12 vdout0_12ck30 = 0 time = 155
* CHECK dout0_13 vdout0_13ck30 = 0 time = 155
* CHECK dout0_14 vdout0_14ck30 = 0 time = 155
* CHECK dout0_15 vdout0_15ck30 = 0 time = 155
* CHECK dout0_16 vdout0_16ck30 = 3.3 time = 155
* CHECK dout0_17 vdout0_17ck30 = 3.3 time = 155
* CHECK dout0_18 vdout0_18ck30 = 3.3 time = 155
* CHECK dout0_19 vdout0_19ck30 = 0 time = 155
* CHECK dout0_20 vdout0_20ck30 = 3.3 time = 155
* CHECK dout0_21 vdout0_21ck30 = 0 time = 155
* CHECK dout0_22 vdout0_22ck30 = 3.3 time = 155
* CHECK dout0_23 vdout0_23ck30 = 0 time = 155
* CHECK dout0_24 vdout0_24ck30 = 3.3 time = 155
* CHECK dout0_25 vdout0_25ck30 = 3.3 time = 155
* CHECK dout0_26 vdout0_26ck30 = 0 time = 155
* CHECK dout0_27 vdout0_27ck30 = 3.3 time = 155
* CHECK dout0_28 vdout0_28ck30 = 3.3 time = 155
* CHECK dout0_29 vdout0_29ck30 = 3.3 time = 155
* CHECK dout0_30 vdout0_30ck30 = 0 time = 155
* CHECK dout0_31 vdout0_31ck30 = 3.3 time = 155
* CHECK dout0_0 vdout0_0ck31 = 0 time = 160
* CHECK dout0_1 vdout0_1ck31 = 3.3 time = 160
* CHECK dout0_2 vdout0_2ck31 = 0 time = 160
* CHECK dout0_3 vdout0_3ck31 = 3.3 time = 160
* CHECK dout0_4 vdout0_4ck31 = 3.3 time = 160
* CHECK dout0_5 vdout0_5ck31 = 0 time = 160
* CHECK dout0_6 vdout0_6ck31 = 0 time = 160
* CHECK dout0_7 vdout0_7ck31 = 0 time = 160
* CHECK dout0_8 vdout0_8ck31 = 0 time = 160
* CHECK dout0_9 vdout0_9ck31 = 3.3 time = 160
* CHECK dout0_10 vdout0_10ck31 = 3.3 time = 160
* CHECK dout0_11 vdout0_11ck31 = 0 time = 160
* CHECK dout0_12 vdout0_12ck31 = 0 time = 160
* CHECK dout0_13 vdout0_13ck31 = 0 time = 160
* CHECK dout0_14 vdout0_14ck31 = 3.3 time = 160
* CHECK dout0_15 vdout0_15ck31 = 0 time = 160
* CHECK dout0_16 vdout0_16ck31 = 0 time = 160
* CHECK dout0_17 vdout0_17ck31 = 3.3 time = 160
* CHECK dout0_18 vdout0_18ck31 = 3.3 time = 160
* CHECK dout0_19 vdout0_19ck31 = 0 time = 160
* CHECK dout0_20 vdout0_20ck31 = 0 time = 160
* CHECK dout0_21 vdout0_21ck31 = 0 time = 160
* CHECK dout0_22 vdout0_22ck31 = 0 time = 160
* CHECK dout0_23 vdout0_23ck31 = 3.3 time = 160
* CHECK dout0_24 vdout0_24ck31 = 0 time = 160
* CHECK dout0_25 vdout0_25ck31 = 0 time = 160
* CHECK dout0_26 vdout0_26ck31 = 3.3 time = 160
* CHECK dout0_27 vdout0_27ck31 = 3.3 time = 160
* CHECK dout0_28 vdout0_28ck31 = 0 time = 160
* CHECK dout0_29 vdout0_29ck31 = 0 time = 160
* CHECK dout0_30 vdout0_30ck31 = 0 time = 160
* CHECK dout0_31 vdout0_31ck31 = 3.3 time = 160
* CHECK dout0_0 vdout0_0ck34 = 0 time = 175
* CHECK dout0_1 vdout0_1ck34 = 0 time = 175
* CHECK dout0_2 vdout0_2ck34 = 0 time = 175
* CHECK dout0_3 vdout0_3ck34 = 0 time = 175
* CHECK dout0_4 vdout0_4ck34 = 0 time = 175
* CHECK dout0_5 vdout0_5ck34 = 0 time = 175
* CHECK dout0_6 vdout0_6ck34 = 3.3 time = 175
* CHECK dout0_7 vdout0_7ck34 = 0 time = 175
* CHECK dout0_8 vdout0_8ck34 = 3.3 time = 175
* CHECK dout0_9 vdout0_9ck34 = 0 time = 175
* CHECK dout0_10 vdout0_10ck34 = 3.3 time = 175
* CHECK dout0_11 vdout0_11ck34 = 0 time = 175
* CHECK dout0_12 vdout0_12ck34 = 0 time = 175
* CHECK dout0_13 vdout0_13ck34 = 0 time = 175
* CHECK dout0_14 vdout0_14ck34 = 0 time = 175
* CHECK dout0_15 vdout0_15ck34 = 0 time = 175
* CHECK dout0_16 vdout0_16ck34 = 3.3 time = 175
* CHECK dout0_17 vdout0_17ck34 = 3.3 time = 175
* CHECK dout0_18 vdout0_18ck34 = 3.3 time = 175
* CHECK dout0_19 vdout0_19ck34 = 0 time = 175
* CHECK dout0_20 vdout0_20ck34 = 3.3 time = 175
* CHECK dout0_21 vdout0_21ck34 = 0 time = 175
* CHECK dout0_22 vdout0_22ck34 = 3.3 time = 175
* CHECK dout0_23 vdout0_23ck34 = 0 time = 175
* CHECK dout0_24 vdout0_24ck34 = 3.3 time = 175
* CHECK dout0_25 vdout0_25ck34 = 3.3 time = 175
* CHECK dout0_26 vdout0_26ck34 = 0 time = 175
* CHECK dout0_27 vdout0_27ck34 = 3.3 time = 175
* CHECK dout0_28 vdout0_28ck34 = 3.3 time = 175
* CHECK dout0_29 vdout0_29ck34 = 3.3 time = 175
* CHECK dout0_30 vdout0_30ck34 = 0 time = 175
* CHECK dout0_31 vdout0_31ck34 = 3.3 time = 175
* CHECK dout0_0 vdout0_0ck38 = 0 time = 195
* CHECK dout0_1 vdout0_1ck38 = 0 time = 195
* CHECK dout0_2 vdout0_2ck38 = 0 time = 195
* CHECK dout0_3 vdout0_3ck38 = 0 time = 195
* CHECK dout0_4 vdout0_4ck38 = 0 time = 195
* CHECK dout0_5 vdout0_5ck38 = 3.3 time = 195
* CHECK dout0_6 vdout0_6ck38 = 0 time = 195
* CHECK dout0_7 vdout0_7ck38 = 0 time = 195
* CHECK dout0_8 vdout0_8ck38 = 3.3 time = 195
* CHECK dout0_9 vdout0_9ck38 = 3.3 time = 195
* CHECK dout0_10 vdout0_10ck38 = 3.3 time = 195
* CHECK dout0_11 vdout0_11ck38 = 3.3 time = 195
* CHECK dout0_12 vdout0_12ck38 = 0 time = 195
* CHECK dout0_13 vdout0_13ck38 = 0 time = 195
* CHECK dout0_14 vdout0_14ck38 = 3.3 time = 195
* CHECK dout0_15 vdout0_15ck38 = 0 time = 195
* CHECK dout0_16 vdout0_16ck38 = 0 time = 195
* CHECK dout0_17 vdout0_17ck38 = 0 time = 195
* CHECK dout0_18 vdout0_18ck38 = 0 time = 195
* CHECK dout0_19 vdout0_19ck38 = 0 time = 195
* CHECK dout0_20 vdout0_20ck38 = 0 time = 195
* CHECK dout0_21 vdout0_21ck38 = 3.3 time = 195
* CHECK dout0_22 vdout0_22ck38 = 3.3 time = 195
* CHECK dout0_23 vdout0_23ck38 = 0 time = 195
* CHECK dout0_24 vdout0_24ck38 = 3.3 time = 195
* CHECK dout0_25 vdout0_25ck38 = 3.3 time = 195
* CHECK dout0_26 vdout0_26ck38 = 0 time = 195
* CHECK dout0_27 vdout0_27ck38 = 3.3 time = 195
* CHECK dout0_28 vdout0_28ck38 = 3.3 time = 195
* CHECK dout0_29 vdout0_29ck38 = 0 time = 195
* CHECK dout0_30 vdout0_30ck38 = 0 time = 195
* CHECK dout0_31 vdout0_31ck38 = 3.3 time = 195
* CHECK dout0_0 vdout0_0ck39 = 3.3 time = 200
* CHECK dout0_1 vdout0_1ck39 = 0 time = 200
* CHECK dout0_2 vdout0_2ck39 = 0 time = 200
* CHECK dout0_3 vdout0_3ck39 = 0 time = 200
* CHECK dout0_4 vdout0_4ck39 = 0 time = 200
* CHECK dout0_5 vdout0_5ck39 = 0 time = 200
* CHECK dout0_6 vdout0_6ck39 = 0 time = 200
* CHECK dout0_7 vdout0_7ck39 = 3.3 time = 200
* CHECK dout0_8 vdout0_8ck39 = 0 time = 200
* CHECK dout0_9 vdout0_9ck39 = 3.3 time = 200
* CHECK dout0_10 vdout0_10ck39 = 3.3 time = 200
* CHECK dout0_11 vdout0_11ck39 = 3.3 time = 200
* CHECK dout0_12 vdout0_12ck39 = 3.3 time = 200
* CHECK dout0_13 vdout0_13ck39 = 3.3 time = 200
* CHECK dout0_14 vdout0_14ck39 = 3.3 time = 200
* CHECK dout0_15 vdout0_15ck39 = 0 time = 200
* CHECK dout0_16 vdout0_16ck39 = 0 time = 200
* CHECK dout0_17 vdout0_17ck39 = 3.3 time = 200
* CHECK dout0_18 vdout0_18ck39 = 3.3 time = 200
* CHECK dout0_19 vdout0_19ck39 = 3.3 time = 200
* CHECK dout0_20 vdout0_20ck39 = 0 time = 200
* CHECK dout0_21 vdout0_21ck39 = 0 time = 200
* CHECK dout0_22 vdout0_22ck39 = 0 time = 200
* CHECK dout0_23 vdout0_23ck39 = 0 time = 200
* CHECK dout0_24 vdout0_24ck39 = 0 time = 200
* CHECK dout0_25 vdout0_25ck39 = 3.3 time = 200
* CHECK dout0_26 vdout0_26ck39 = 3.3 time = 200
* CHECK dout0_27 vdout0_27ck39 = 0 time = 200
* CHECK dout0_28 vdout0_28ck39 = 3.3 time = 200
* CHECK dout0_29 vdout0_29ck39 = 0 time = 200
* CHECK dout0_30 vdout0_30ck39 = 0 time = 200
* CHECK dout0_31 vdout0_31ck39 = 3.3 time = 200
* CHECK dout0_0 vdout0_0ck41 = 3.3 time = 210
* CHECK dout0_1 vdout0_1ck41 = 0 time = 210
* CHECK dout0_2 vdout0_2ck41 = 0 time = 210
* CHECK dout0_3 vdout0_3ck41 = 0 time = 210
* CHECK dout0_4 vdout0_4ck41 = 0 time = 210
* CHECK dout0_5 vdout0_5ck41 = 0 time = 210
* CHECK dout0_6 vdout0_6ck41 = 0 time = 210
* CHECK dout0_7 vdout0_7ck41 = 3.3 time = 210
* CHECK dout0_8 vdout0_8ck41 = 0 time = 210
* CHECK dout0_9 vdout0_9ck41 = 3.3 time = 210
* CHECK dout0_10 vdout0_10ck41 = 3.3 time = 210
* CHECK dout0_11 vdout0_11ck41 = 3.3 time = 210
* CHECK dout0_12 vdout0_12ck41 = 3.3 time = 210
* CHECK dout0_13 vdout0_13ck41 = 3.3 time = 210
* CHECK dout0_14 vdout0_14ck41 = 3.3 time = 210
* CHECK dout0_15 vdout0_15ck41 = 0 time = 210
* CHECK dout0_16 vdout0_16ck41 = 0 time = 210
* CHECK dout0_17 vdout0_17ck41 = 3.3 time = 210
* CHECK dout0_18 vdout0_18ck41 = 3.3 time = 210
* CHECK dout0_19 vdout0_19ck41 = 3.3 time = 210
* CHECK dout0_20 vdout0_20ck41 = 0 time = 210
* CHECK dout0_21 vdout0_21ck41 = 0 time = 210
* CHECK dout0_22 vdout0_22ck41 = 0 time = 210
* CHECK dout0_23 vdout0_23ck41 = 0 time = 210
* CHECK dout0_24 vdout0_24ck41 = 0 time = 210
* CHECK dout0_25 vdout0_25ck41 = 3.3 time = 210
* CHECK dout0_26 vdout0_26ck41 = 3.3 time = 210
* CHECK dout0_27 vdout0_27ck41 = 0 time = 210
* CHECK dout0_28 vdout0_28ck41 = 3.3 time = 210
* CHECK dout0_29 vdout0_29ck41 = 0 time = 210
* CHECK dout0_30 vdout0_30ck41 = 0 time = 210
* CHECK dout0_31 vdout0_31ck41 = 3.3 time = 210
* CHECK dout0_0 vdout0_0ck44 = 3.3 time = 225
* CHECK dout0_1 vdout0_1ck44 = 0 time = 225
* CHECK dout0_2 vdout0_2ck44 = 0 time = 225
* CHECK dout0_3 vdout0_3ck44 = 0 time = 225
* CHECK dout0_4 vdout0_4ck44 = 0 time = 225
* CHECK dout0_5 vdout0_5ck44 = 0 time = 225
* CHECK dout0_6 vdout0_6ck44 = 0 time = 225
* CHECK dout0_7 vdout0_7ck44 = 3.3 time = 225
* CHECK dout0_8 vdout0_8ck44 = 0 time = 225
* CHECK dout0_9 vdout0_9ck44 = 3.3 time = 225
* CHECK dout0_10 vdout0_10ck44 = 3.3 time = 225
* CHECK dout0_11 vdout0_11ck44 = 3.3 time = 225
* CHECK dout0_12 vdout0_12ck44 = 3.3 time = 225
* CHECK dout0_13 vdout0_13ck44 = 3.3 time = 225
* CHECK dout0_14 vdout0_14ck44 = 3.3 time = 225
* CHECK dout0_15 vdout0_15ck44 = 0 time = 225
* CHECK dout0_16 vdout0_16ck44 = 0 time = 225
* CHECK dout0_17 vdout0_17ck44 = 3.3 time = 225
* CHECK dout0_18 vdout0_18ck44 = 3.3 time = 225
* CHECK dout0_19 vdout0_19ck44 = 3.3 time = 225
* CHECK dout0_20 vdout0_20ck44 = 0 time = 225
* CHECK dout0_21 vdout0_21ck44 = 0 time = 225
* CHECK dout0_22 vdout0_22ck44 = 0 time = 225
* CHECK dout0_23 vdout0_23ck44 = 0 time = 225
* CHECK dout0_24 vdout0_24ck44 = 0 time = 225
* CHECK dout0_25 vdout0_25ck44 = 3.3 time = 225
* CHECK dout0_26 vdout0_26ck44 = 3.3 time = 225
* CHECK dout0_27 vdout0_27ck44 = 0 time = 225
* CHECK dout0_28 vdout0_28ck44 = 3.3 time = 225
* CHECK dout0_29 vdout0_29ck44 = 0 time = 225
* CHECK dout0_30 vdout0_30ck44 = 0 time = 225
* CHECK dout0_31 vdout0_31ck44 = 3.3 time = 225
* CHECK dout0_0 vdout0_0ck47 = 3.3 time = 240
* CHECK dout0_1 vdout0_1ck47 = 0 time = 240
* CHECK dout0_2 vdout0_2ck47 = 0 time = 240
* CHECK dout0_3 vdout0_3ck47 = 0 time = 240
* CHECK dout0_4 vdout0_4ck47 = 0 time = 240
* CHECK dout0_5 vdout0_5ck47 = 0 time = 240
* CHECK dout0_6 vdout0_6ck47 = 0 time = 240
* CHECK dout0_7 vdout0_7ck47 = 3.3 time = 240
* CHECK dout0_8 vdout0_8ck47 = 0 time = 240
* CHECK dout0_9 vdout0_9ck47 = 3.3 time = 240
* CHECK dout0_10 vdout0_10ck47 = 3.3 time = 240
* CHECK dout0_11 vdout0_11ck47 = 3.3 time = 240
* CHECK dout0_12 vdout0_12ck47 = 3.3 time = 240
* CHECK dout0_13 vdout0_13ck47 = 3.3 time = 240
* CHECK dout0_14 vdout0_14ck47 = 3.3 time = 240
* CHECK dout0_15 vdout0_15ck47 = 0 time = 240
* CHECK dout0_16 vdout0_16ck47 = 0 time = 240
* CHECK dout0_17 vdout0_17ck47 = 3.3 time = 240
* CHECK dout0_18 vdout0_18ck47 = 3.3 time = 240
* CHECK dout0_19 vdout0_19ck47 = 3.3 time = 240
* CHECK dout0_20 vdout0_20ck47 = 0 time = 240
* CHECK dout0_21 vdout0_21ck47 = 0 time = 240
* CHECK dout0_22 vdout0_22ck47 = 0 time = 240
* CHECK dout0_23 vdout0_23ck47 = 0 time = 240
* CHECK dout0_24 vdout0_24ck47 = 0 time = 240
* CHECK dout0_25 vdout0_25ck47 = 3.3 time = 240
* CHECK dout0_26 vdout0_26ck47 = 3.3 time = 240
* CHECK dout0_27 vdout0_27ck47 = 0 time = 240
* CHECK dout0_28 vdout0_28ck47 = 3.3 time = 240
* CHECK dout0_29 vdout0_29ck47 = 0 time = 240
* CHECK dout0_30 vdout0_30ck47 = 0 time = 240
* CHECK dout0_31 vdout0_31ck47 = 3.3 time = 240
* CHECK dout0_0 vdout0_0ck48 = 0 time = 245
* CHECK dout0_1 vdout0_1ck48 = 0 time = 245
* CHECK dout0_2 vdout0_2ck48 = 3.3 time = 245
* CHECK dout0_3 vdout0_3ck48 = 0 time = 245
* CHECK dout0_4 vdout0_4ck48 = 3.3 time = 245
* CHECK dout0_5 vdout0_5ck48 = 3.3 time = 245
* CHECK dout0_6 vdout0_6ck48 = 3.3 time = 245
* CHECK dout0_7 vdout0_7ck48 = 0 time = 245
* CHECK dout0_8 vdout0_8ck48 = 0 time = 245
* CHECK dout0_9 vdout0_9ck48 = 0 time = 245
* CHECK dout0_10 vdout0_10ck48 = 0 time = 245
* CHECK dout0_11 vdout0_11ck48 = 0 time = 245
* CHECK dout0_12 vdout0_12ck48 = 3.3 time = 245
* CHECK dout0_13 vdout0_13ck48 = 0 time = 245
* CHECK dout0_14 vdout0_14ck48 = 0 time = 245
* CHECK dout0_15 vdout0_15ck48 = 0 time = 245
* CHECK dout0_16 vdout0_16ck48 = 0 time = 245
* CHECK dout0_17 vdout0_17ck48 = 0 time = 245
* CHECK dout0_18 vdout0_18ck48 = 0 time = 245
* CHECK dout0_19 vdout0_19ck48 = 0 time = 245
* CHECK dout0_20 vdout0_20ck48 = 3.3 time = 245
* CHECK dout0_21 vdout0_21ck48 = 0 time = 245
* CHECK dout0_22 vdout0_22ck48 = 0 time = 245
* CHECK dout0_23 vdout0_23ck48 = 0 time = 245
* CHECK dout0_24 vdout0_24ck48 = 3.3 time = 245
* CHECK dout0_25 vdout0_25ck48 = 0 time = 245
* CHECK dout0_26 vdout0_26ck48 = 0 time = 245
* CHECK dout0_27 vdout0_27ck48 = 0 time = 245
* CHECK dout0_28 vdout0_28ck48 = 3.3 time = 245
* CHECK dout0_29 vdout0_29ck48 = 3.3 time = 245
* CHECK dout0_30 vdout0_30ck48 = 0 time = 245
* CHECK dout0_31 vdout0_31ck48 = 3.3 time = 245
* CHECK dout0_0 vdout0_0ck52 = 3.3 time = 265
* CHECK dout0_1 vdout0_1ck52 = 0 time = 265
* CHECK dout0_2 vdout0_2ck52 = 3.3 time = 265
* CHECK dout0_3 vdout0_3ck52 = 0 time = 265
* CHECK dout0_4 vdout0_4ck52 = 3.3 time = 265
* CHECK dout0_5 vdout0_5ck52 = 0 time = 265
* CHECK dout0_6 vdout0_6ck52 = 0 time = 265
* CHECK dout0_7 vdout0_7ck52 = 3.3 time = 265
* CHECK dout0_8 vdout0_8ck52 = 3.3 time = 265
* CHECK dout0_9 vdout0_9ck52 = 0 time = 265
* CHECK dout0_10 vdout0_10ck52 = 0 time = 265
* CHECK dout0_11 vdout0_11ck52 = 0 time = 265
* CHECK dout0_12 vdout0_12ck52 = 3.3 time = 265
* CHECK dout0_13 vdout0_13ck52 = 0 time = 265
* CHECK dout0_14 vdout0_14ck52 = 3.3 time = 265
* CHECK dout0_15 vdout0_15ck52 = 0 time = 265
* CHECK dout0_16 vdout0_16ck52 = 3.3 time = 265
* CHECK dout0_17 vdout0_17ck52 = 3.3 time = 265
* CHECK dout0_18 vdout0_18ck52 = 0 time = 265
* CHECK dout0_19 vdout0_19ck52 = 0 time = 265
* CHECK dout0_20 vdout0_20ck52 = 3.3 time = 265
* CHECK dout0_21 vdout0_21ck52 = 3.3 time = 265
* CHECK dout0_22 vdout0_22ck52 = 3.3 time = 265
* CHECK dout0_23 vdout0_23ck52 = 3.3 time = 265
* CHECK dout0_24 vdout0_24ck52 = 3.3 time = 265
* CHECK dout0_25 vdout0_25ck52 = 3.3 time = 265
* CHECK dout0_26 vdout0_26ck52 = 3.3 time = 265
* CHECK dout0_27 vdout0_27ck52 = 3.3 time = 265
* CHECK dout0_28 vdout0_28ck52 = 3.3 time = 265
* CHECK dout0_29 vdout0_29ck52 = 0 time = 265
* CHECK dout0_30 vdout0_30ck52 = 3.3 time = 265
* CHECK dout0_31 vdout0_31ck52 = 0 time = 265
* CHECK dout0_0 vdout0_0ck54 = 3.3 time = 275
* CHECK dout0_1 vdout0_1ck54 = 0 time = 275
* CHECK dout0_2 vdout0_2ck54 = 3.3 time = 275
* CHECK dout0_3 vdout0_3ck54 = 0 time = 275
* CHECK dout0_4 vdout0_4ck54 = 3.3 time = 275
* CHECK dout0_5 vdout0_5ck54 = 0 time = 275
* CHECK dout0_6 vdout0_6ck54 = 0 time = 275
* CHECK dout0_7 vdout0_7ck54 = 3.3 time = 275
* CHECK dout0_8 vdout0_8ck54 = 3.3 time = 275
* CHECK dout0_9 vdout0_9ck54 = 0 time = 275
* CHECK dout0_10 vdout0_10ck54 = 0 time = 275
* CHECK dout0_11 vdout0_11ck54 = 0 time = 275
* CHECK dout0_12 vdout0_12ck54 = 3.3 time = 275
* CHECK dout0_13 vdout0_13ck54 = 0 time = 275
* CHECK dout0_14 vdout0_14ck54 = 3.3 time = 275
* CHECK dout0_15 vdout0_15ck54 = 0 time = 275
* CHECK dout0_16 vdout0_16ck54 = 3.3 time = 275
* CHECK dout0_17 vdout0_17ck54 = 3.3 time = 275
* CHECK dout0_18 vdout0_18ck54 = 0 time = 275
* CHECK dout0_19 vdout0_19ck54 = 0 time = 275
* CHECK dout0_20 vdout0_20ck54 = 3.3 time = 275
* CHECK dout0_21 vdout0_21ck54 = 3.3 time = 275
* CHECK dout0_22 vdout0_22ck54 = 3.3 time = 275
* CHECK dout0_23 vdout0_23ck54 = 3.3 time = 275
* CHECK dout0_24 vdout0_24ck54 = 3.3 time = 275
* CHECK dout0_25 vdout0_25ck54 = 3.3 time = 275
* CHECK dout0_26 vdout0_26ck54 = 3.3 time = 275
* CHECK dout0_27 vdout0_27ck54 = 3.3 time = 275
* CHECK dout0_28 vdout0_28ck54 = 3.3 time = 275
* CHECK dout0_29 vdout0_29ck54 = 0 time = 275
* CHECK dout0_30 vdout0_30ck54 = 3.3 time = 275
* CHECK dout0_31 vdout0_31ck54 = 0 time = 275
* CHECK dout0_0 vdout0_0ck55 = 3.3 time = 280
* CHECK dout0_1 vdout0_1ck55 = 0 time = 280
* CHECK dout0_2 vdout0_2ck55 = 3.3 time = 280
* CHECK dout0_3 vdout0_3ck55 = 0 time = 280
* CHECK dout0_4 vdout0_4ck55 = 3.3 time = 280
* CHECK dout0_5 vdout0_5ck55 = 0 time = 280
* CHECK dout0_6 vdout0_6ck55 = 0 time = 280
* CHECK dout0_7 vdout0_7ck55 = 3.3 time = 280
* CHECK dout0_8 vdout0_8ck55 = 3.3 time = 280
* CHECK dout0_9 vdout0_9ck55 = 0 time = 280
* CHECK dout0_10 vdout0_10ck55 = 0 time = 280
* CHECK dout0_11 vdout0_11ck55 = 0 time = 280
* CHECK dout0_12 vdout0_12ck55 = 3.3 time = 280
* CHECK dout0_13 vdout0_13ck55 = 0 time = 280
* CHECK dout0_14 vdout0_14ck55 = 3.3 time = 280
* CHECK dout0_15 vdout0_15ck55 = 0 time = 280
* CHECK dout0_16 vdout0_16ck55 = 3.3 time = 280
* CHECK dout0_17 vdout0_17ck55 = 3.3 time = 280
* CHECK dout0_18 vdout0_18ck55 = 0 time = 280
* CHECK dout0_19 vdout0_19ck55 = 0 time = 280
* CHECK dout0_20 vdout0_20ck55 = 3.3 time = 280
* CHECK dout0_21 vdout0_21ck55 = 3.3 time = 280
* CHECK dout0_22 vdout0_22ck55 = 3.3 time = 280
* CHECK dout0_23 vdout0_23ck55 = 3.3 time = 280
* CHECK dout0_24 vdout0_24ck55 = 3.3 time = 280
* CHECK dout0_25 vdout0_25ck55 = 3.3 time = 280
* CHECK dout0_26 vdout0_26ck55 = 3.3 time = 280
* CHECK dout0_27 vdout0_27ck55 = 3.3 time = 280
* CHECK dout0_28 vdout0_28ck55 = 3.3 time = 280
* CHECK dout0_29 vdout0_29ck55 = 0 time = 280
* CHECK dout0_30 vdout0_30ck55 = 3.3 time = 280
* CHECK dout0_31 vdout0_31ck55 = 0 time = 280
* CHECK dout0_0 vdout0_0ck57 = 0 time = 290
* CHECK dout0_1 vdout0_1ck57 = 0 time = 290
* CHECK dout0_2 vdout0_2ck57 = 0 time = 290
* CHECK dout0_3 vdout0_3ck57 = 3.3 time = 290
* CHECK dout0_4 vdout0_4ck57 = 0 time = 290
* CHECK dout0_5 vdout0_5ck57 = 3.3 time = 290
* CHECK dout0_6 vdout0_6ck57 = 0 time = 290
* CHECK dout0_7 vdout0_7ck57 = 3.3 time = 290
* CHECK dout0_8 vdout0_8ck57 = 3.3 time = 290
* CHECK dout0_9 vdout0_9ck57 = 3.3 time = 290
* CHECK dout0_10 vdout0_10ck57 = 0 time = 290
* CHECK dout0_11 vdout0_11ck57 = 0 time = 290
* CHECK dout0_12 vdout0_12ck57 = 3.3 time = 290
* CHECK dout0_13 vdout0_13ck57 = 3.3 time = 290
* CHECK dout0_14 vdout0_14ck57 = 0 time = 290
* CHECK dout0_15 vdout0_15ck57 = 0 time = 290
* CHECK dout0_16 vdout0_16ck57 = 0 time = 290
* CHECK dout0_17 vdout0_17ck57 = 0 time = 290
* CHECK dout0_18 vdout0_18ck57 = 0 time = 290
* CHECK dout0_19 vdout0_19ck57 = 3.3 time = 290
* CHECK dout0_20 vdout0_20ck57 = 0 time = 290
* CHECK dout0_21 vdout0_21ck57 = 3.3 time = 290
* CHECK dout0_22 vdout0_22ck57 = 3.3 time = 290
* CHECK dout0_23 vdout0_23ck57 = 0 time = 290
* CHECK dout0_24 vdout0_24ck57 = 3.3 time = 290
* CHECK dout0_25 vdout0_25ck57 = 3.3 time = 290
* CHECK dout0_26 vdout0_26ck57 = 3.3 time = 290
* CHECK dout0_27 vdout0_27ck57 = 0 time = 290
* CHECK dout0_28 vdout0_28ck57 = 3.3 time = 290
* CHECK dout0_29 vdout0_29ck57 = 3.3 time = 290
* CHECK dout0_30 vdout0_30ck57 = 0 time = 290
* CHECK dout0_31 vdout0_31ck57 = 0 time = 290
* CHECK dout0_0 vdout0_0ck59 = 0 time = 300
* CHECK dout0_1 vdout0_1ck59 = 0 time = 300
* CHECK dout0_2 vdout0_2ck59 = 0 time = 300
* CHECK dout0_3 vdout0_3ck59 = 3.3 time = 300
* CHECK dout0_4 vdout0_4ck59 = 3.3 time = 300
* CHECK dout0_5 vdout0_5ck59 = 3.3 time = 300
* CHECK dout0_6 vdout0_6ck59 = 0 time = 300
* CHECK dout0_7 vdout0_7ck59 = 3.3 time = 300
* CHECK dout0_8 vdout0_8ck59 = 3.3 time = 300
* CHECK dout0_9 vdout0_9ck59 = 3.3 time = 300
* CHECK dout0_10 vdout0_10ck59 = 0 time = 300
* CHECK dout0_11 vdout0_11ck59 = 3.3 time = 300
* CHECK dout0_12 vdout0_12ck59 = 3.3 time = 300
* CHECK dout0_13 vdout0_13ck59 = 0 time = 300
* CHECK dout0_14 vdout0_14ck59 = 0 time = 300
* CHECK dout0_15 vdout0_15ck59 = 3.3 time = 300
* CHECK dout0_16 vdout0_16ck59 = 3.3 time = 300
* CHECK dout0_17 vdout0_17ck59 = 3.3 time = 300
* CHECK dout0_18 vdout0_18ck59 = 0 time = 300
* CHECK dout0_19 vdout0_19ck59 = 0 time = 300
* CHECK dout0_20 vdout0_20ck59 = 0 time = 300
* CHECK dout0_21 vdout0_21ck59 = 3.3 time = 300
* CHECK dout0_22 vdout0_22ck59 = 3.3 time = 300
* CHECK dout0_23 vdout0_23ck59 = 3.3 time = 300
* CHECK dout0_24 vdout0_24ck59 = 0 time = 300
* CHECK dout0_25 vdout0_25ck59 = 0 time = 300
* CHECK dout0_26 vdout0_26ck59 = 3.3 time = 300
* CHECK dout0_27 vdout0_27ck59 = 0 time = 300
* CHECK dout0_28 vdout0_28ck59 = 3.3 time = 300
* CHECK dout0_29 vdout0_29ck59 = 3.3 time = 300
* CHECK dout0_30 vdout0_30ck59 = 0 time = 300
* CHECK dout0_31 vdout0_31ck59 = 0 time = 300
* CHECK dout0_0 vdout0_0ck62 = 3.3 time = 315
* CHECK dout0_1 vdout0_1ck62 = 0 time = 315
* CHECK dout0_2 vdout0_2ck62 = 3.3 time = 315
* CHECK dout0_3 vdout0_3ck62 = 0 time = 315
* CHECK dout0_4 vdout0_4ck62 = 3.3 time = 315
* CHECK dout0_5 vdout0_5ck62 = 0 time = 315
* CHECK dout0_6 vdout0_6ck62 = 3.3 time = 315
* CHECK dout0_7 vdout0_7ck62 = 0 time = 315
* CHECK dout0_8 vdout0_8ck62 = 0 time = 315
* CHECK dout0_9 vdout0_9ck62 = 3.3 time = 315
* CHECK dout0_10 vdout0_10ck62 = 3.3 time = 315
* CHECK dout0_11 vdout0_11ck62 = 0 time = 315
* CHECK dout0_12 vdout0_12ck62 = 3.3 time = 315
* CHECK dout0_13 vdout0_13ck62 = 3.3 time = 315
* CHECK dout0_14 vdout0_14ck62 = 3.3 time = 315
* CHECK dout0_15 vdout0_15ck62 = 3.3 time = 315
* CHECK dout0_16 vdout0_16ck62 = 3.3 time = 315
* CHECK dout0_17 vdout0_17ck62 = 0 time = 315
* CHECK dout0_18 vdout0_18ck62 = 3.3 time = 315
* CHECK dout0_19 vdout0_19ck62 = 3.3 time = 315
* CHECK dout0_20 vdout0_20ck62 = 0 time = 315
* CHECK dout0_21 vdout0_21ck62 = 3.3 time = 315
* CHECK dout0_22 vdout0_22ck62 = 3.3 time = 315
* CHECK dout0_23 vdout0_23ck62 = 3.3 time = 315
* CHECK dout0_24 vdout0_24ck62 = 0 time = 315
* CHECK dout0_25 vdout0_25ck62 = 3.3 time = 315
* CHECK dout0_26 vdout0_26ck62 = 3.3 time = 315
* CHECK dout0_27 vdout0_27ck62 = 3.3 time = 315
* CHECK dout0_28 vdout0_28ck62 = 0 time = 315
* CHECK dout0_29 vdout0_29ck62 = 3.3 time = 315
* CHECK dout0_30 vdout0_30ck62 = 0 time = 315
* CHECK dout0_31 vdout0_31ck62 = 3.3 time = 315
* CHECK dout0_0 vdout0_0ck63 = 3.3 time = 320
* CHECK dout0_1 vdout0_1ck63 = 0 time = 320
* CHECK dout0_2 vdout0_2ck63 = 3.3 time = 320
* CHECK dout0_3 vdout0_3ck63 = 3.3 time = 320
* CHECK dout0_4 vdout0_4ck63 = 3.3 time = 320
* CHECK dout0_5 vdout0_5ck63 = 0 time = 320
* CHECK dout0_6 vdout0_6ck63 = 3.3 time = 320
* CHECK dout0_7 vdout0_7ck63 = 3.3 time = 320
* CHECK dout0_8 vdout0_8ck63 = 3.3 time = 320
* CHECK dout0_9 vdout0_9ck63 = 0 time = 320
* CHECK dout0_10 vdout0_10ck63 = 0 time = 320
* CHECK dout0_11 vdout0_11ck63 = 3.3 time = 320
* CHECK dout0_12 vdout0_12ck63 = 0 time = 320
* CHECK dout0_13 vdout0_13ck63 = 0 time = 320
* CHECK dout0_14 vdout0_14ck63 = 0 time = 320
* CHECK dout0_15 vdout0_15ck63 = 3.3 time = 320
* CHECK dout0_16 vdout0_16ck63 = 0 time = 320
* CHECK dout0_17 vdout0_17ck63 = 0 time = 320
* CHECK dout0_18 vdout0_18ck63 = 0 time = 320
* CHECK dout0_19 vdout0_19ck63 = 3.3 time = 320
* CHECK dout0_20 vdout0_20ck63 = 3.3 time = 320
* CHECK dout0_21 vdout0_21ck63 = 3.3 time = 320
* CHECK dout0_22 vdout0_22ck63 = 3.3 time = 320
* CHECK dout0_23 vdout0_23ck63 = 0 time = 320
* CHECK dout0_24 vdout0_24ck63 = 0 time = 320
* CHECK dout0_25 vdout0_25ck63 = 0 time = 320
* CHECK dout0_26 vdout0_26ck63 = 0 time = 320
* CHECK dout0_27 vdout0_27ck63 = 0 time = 320
* CHECK dout0_28 vdout0_28ck63 = 3.3 time = 320
* CHECK dout0_29 vdout0_29ck63 = 3.3 time = 320
* CHECK dout0_30 vdout0_30ck63 = 3.3 time = 320
* CHECK dout0_31 vdout0_31ck63 = 3.3 time = 320
* CHECK dout0_0 vdout0_0ck69 = 3.3 time = 350
* CHECK dout0_1 vdout0_1ck69 = 3.3 time = 350
* CHECK dout0_2 vdout0_2ck69 = 3.3 time = 350
* CHECK dout0_3 vdout0_3ck69 = 0 time = 350
* CHECK dout0_4 vdout0_4ck69 = 0 time = 350
* CHECK dout0_5 vdout0_5ck69 = 0 time = 350
* CHECK dout0_6 vdout0_6ck69 = 0 time = 350
* CHECK dout0_7 vdout0_7ck69 = 3.3 time = 350
* CHECK dout0_8 vdout0_8ck69 = 0 time = 350
* CHECK dout0_9 vdout0_9ck69 = 3.3 time = 350
* CHECK dout0_10 vdout0_10ck69 = 3.3 time = 350
* CHECK dout0_11 vdout0_11ck69 = 0 time = 350
* CHECK dout0_12 vdout0_12ck69 = 0 time = 350
* CHECK dout0_13 vdout0_13ck69 = 3.3 time = 350
* CHECK dout0_14 vdout0_14ck69 = 0 time = 350
* CHECK dout0_15 vdout0_15ck69 = 3.3 time = 350
* CHECK dout0_16 vdout0_16ck69 = 0 time = 350
* CHECK dout0_17 vdout0_17ck69 = 0 time = 350
* CHECK dout0_18 vdout0_18ck69 = 3.3 time = 350
* CHECK dout0_19 vdout0_19ck69 = 3.3 time = 350
* CHECK dout0_20 vdout0_20ck69 = 3.3 time = 350
* CHECK dout0_21 vdout0_21ck69 = 0 time = 350
* CHECK dout0_22 vdout0_22ck69 = 3.3 time = 350
* CHECK dout0_23 vdout0_23ck69 = 3.3 time = 350
* CHECK dout0_24 vdout0_24ck69 = 0 time = 350
* CHECK dout0_25 vdout0_25ck69 = 3.3 time = 350
* CHECK dout0_26 vdout0_26ck69 = 3.3 time = 350
* CHECK dout0_27 vdout0_27ck69 = 0 time = 350
* CHECK dout0_28 vdout0_28ck69 = 3.3 time = 350
* CHECK dout0_29 vdout0_29ck69 = 0 time = 350
* CHECK dout0_30 vdout0_30ck69 = 3.3 time = 350
* CHECK dout0_31 vdout0_31ck69 = 0 time = 350
* CHECK dout0_0 vdout0_0ck70 = 3.3 time = 355
* CHECK dout0_1 vdout0_1ck70 = 3.3 time = 355
* CHECK dout0_2 vdout0_2ck70 = 3.3 time = 355
* CHECK dout0_3 vdout0_3ck70 = 0 time = 355
* CHECK dout0_4 vdout0_4ck70 = 0 time = 355
* CHECK dout0_5 vdout0_5ck70 = 0 time = 355
* CHECK dout0_6 vdout0_6ck70 = 0 time = 355
* CHECK dout0_7 vdout0_7ck70 = 3.3 time = 355
* CHECK dout0_8 vdout0_8ck70 = 0 time = 355
* CHECK dout0_9 vdout0_9ck70 = 3.3 time = 355
* CHECK dout0_10 vdout0_10ck70 = 3.3 time = 355
* CHECK dout0_11 vdout0_11ck70 = 0 time = 355
* CHECK dout0_12 vdout0_12ck70 = 0 time = 355
* CHECK dout0_13 vdout0_13ck70 = 3.3 time = 355
* CHECK dout0_14 vdout0_14ck70 = 0 time = 355
* CHECK dout0_15 vdout0_15ck70 = 3.3 time = 355
* CHECK dout0_16 vdout0_16ck70 = 0 time = 355
* CHECK dout0_17 vdout0_17ck70 = 0 time = 355
* CHECK dout0_18 vdout0_18ck70 = 3.3 time = 355
* CHECK dout0_19 vdout0_19ck70 = 3.3 time = 355
* CHECK dout0_20 vdout0_20ck70 = 3.3 time = 355
* CHECK dout0_21 vdout0_21ck70 = 0 time = 355
* CHECK dout0_22 vdout0_22ck70 = 3.3 time = 355
* CHECK dout0_23 vdout0_23ck70 = 3.3 time = 355
* CHECK dout0_24 vdout0_24ck70 = 0 time = 355
* CHECK dout0_25 vdout0_25ck70 = 3.3 time = 355
* CHECK dout0_26 vdout0_26ck70 = 3.3 time = 355
* CHECK dout0_27 vdout0_27ck70 = 0 time = 355
* CHECK dout0_28 vdout0_28ck70 = 3.3 time = 355
* CHECK dout0_29 vdout0_29ck70 = 0 time = 355
* CHECK dout0_30 vdout0_30ck70 = 3.3 time = 355
* CHECK dout0_31 vdout0_31ck70 = 0 time = 355
* CHECK dout0_0 vdout0_0ck73 = 3.3 time = 370
* CHECK dout0_1 vdout0_1ck73 = 0 time = 370
* CHECK dout0_2 vdout0_2ck73 = 3.3 time = 370
* CHECK dout0_3 vdout0_3ck73 = 3.3 time = 370
* CHECK dout0_4 vdout0_4ck73 = 3.3 time = 370
* CHECK dout0_5 vdout0_5ck73 = 0 time = 370
* CHECK dout0_6 vdout0_6ck73 = 3.3 time = 370
* CHECK dout0_7 vdout0_7ck73 = 3.3 time = 370
* CHECK dout0_8 vdout0_8ck73 = 3.3 time = 370
* CHECK dout0_9 vdout0_9ck73 = 0 time = 370
* CHECK dout0_10 vdout0_10ck73 = 0 time = 370
* CHECK dout0_11 vdout0_11ck73 = 3.3 time = 370
* CHECK dout0_12 vdout0_12ck73 = 0 time = 370
* CHECK dout0_13 vdout0_13ck73 = 0 time = 370
* CHECK dout0_14 vdout0_14ck73 = 0 time = 370
* CHECK dout0_15 vdout0_15ck73 = 3.3 time = 370
* CHECK dout0_16 vdout0_16ck73 = 0 time = 370
* CHECK dout0_17 vdout0_17ck73 = 0 time = 370
* CHECK dout0_18 vdout0_18ck73 = 0 time = 370
* CHECK dout0_19 vdout0_19ck73 = 3.3 time = 370
* CHECK dout0_20 vdout0_20ck73 = 3.3 time = 370
* CHECK dout0_21 vdout0_21ck73 = 3.3 time = 370
* CHECK dout0_22 vdout0_22ck73 = 3.3 time = 370
* CHECK dout0_23 vdout0_23ck73 = 0 time = 370
* CHECK dout0_24 vdout0_24ck73 = 0 time = 370
* CHECK dout0_25 vdout0_25ck73 = 0 time = 370
* CHECK dout0_26 vdout0_26ck73 = 0 time = 370
* CHECK dout0_27 vdout0_27ck73 = 0 time = 370
* CHECK dout0_28 vdout0_28ck73 = 3.3 time = 370
* CHECK dout0_29 vdout0_29ck73 = 3.3 time = 370
* CHECK dout0_30 vdout0_30ck73 = 3.3 time = 370
* CHECK dout0_31 vdout0_31ck73 = 3.3 time = 370
* CHECK dout0_0 vdout0_0ck74 = 3.3 time = 375
* CHECK dout0_1 vdout0_1ck74 = 3.3 time = 375
* CHECK dout0_2 vdout0_2ck74 = 0 time = 375
* CHECK dout0_3 vdout0_3ck74 = 3.3 time = 375
* CHECK dout0_4 vdout0_4ck74 = 3.3 time = 375
* CHECK dout0_5 vdout0_5ck74 = 3.3 time = 375
* CHECK dout0_6 vdout0_6ck74 = 3.3 time = 375
* CHECK dout0_7 vdout0_7ck74 = 3.3 time = 375
* CHECK dout0_8 vdout0_8ck74 = 3.3 time = 375
* CHECK dout0_9 vdout0_9ck74 = 0 time = 375
* CHECK dout0_10 vdout0_10ck74 = 0 time = 375
* CHECK dout0_11 vdout0_11ck74 = 3.3 time = 375
* CHECK dout0_12 vdout0_12ck74 = 3.3 time = 375
* CHECK dout0_13 vdout0_13ck74 = 3.3 time = 375
* CHECK dout0_14 vdout0_14ck74 = 0 time = 375
* CHECK dout0_15 vdout0_15ck74 = 3.3 time = 375
* CHECK dout0_16 vdout0_16ck74 = 3.3 time = 375
* CHECK dout0_17 vdout0_17ck74 = 3.3 time = 375
* CHECK dout0_18 vdout0_18ck74 = 0 time = 375
* CHECK dout0_19 vdout0_19ck74 = 3.3 time = 375
* CHECK dout0_20 vdout0_20ck74 = 0 time = 375
* CHECK dout0_21 vdout0_21ck74 = 0 time = 375
* CHECK dout0_22 vdout0_22ck74 = 3.3 time = 375
* CHECK dout0_23 vdout0_23ck74 = 3.3 time = 375
* CHECK dout0_24 vdout0_24ck74 = 0 time = 375
* CHECK dout0_25 vdout0_25ck74 = 3.3 time = 375
* CHECK dout0_26 vdout0_26ck74 = 0 time = 375
* CHECK dout0_27 vdout0_27ck74 = 0 time = 375
* CHECK dout0_28 vdout0_28ck74 = 3.3 time = 375
* CHECK dout0_29 vdout0_29ck74 = 0 time = 375
* CHECK dout0_30 vdout0_30ck74 = 3.3 time = 375
* CHECK dout0_31 vdout0_31ck74 = 3.3 time = 375
* CHECK dout0_0 vdout0_0ck75 = 3.3 time = 380
* CHECK dout0_1 vdout0_1ck75 = 3.3 time = 380
* CHECK dout0_2 vdout0_2ck75 = 0 time = 380
* CHECK dout0_3 vdout0_3ck75 = 3.3 time = 380
* CHECK dout0_4 vdout0_4ck75 = 3.3 time = 380
* CHECK dout0_5 vdout0_5ck75 = 3.3 time = 380
* CHECK dout0_6 vdout0_6ck75 = 3.3 time = 380
* CHECK dout0_7 vdout0_7ck75 = 3.3 time = 380
* CHECK dout0_8 vdout0_8ck75 = 3.3 time = 380
* CHECK dout0_9 vdout0_9ck75 = 0 time = 380
* CHECK dout0_10 vdout0_10ck75 = 0 time = 380
* CHECK dout0_11 vdout0_11ck75 = 3.3 time = 380
* CHECK dout0_12 vdout0_12ck75 = 3.3 time = 380
* CHECK dout0_13 vdout0_13ck75 = 3.3 time = 380
* CHECK dout0_14 vdout0_14ck75 = 0 time = 380
* CHECK dout0_15 vdout0_15ck75 = 3.3 time = 380
* CHECK dout0_16 vdout0_16ck75 = 3.3 time = 380
* CHECK dout0_17 vdout0_17ck75 = 3.3 time = 380
* CHECK dout0_18 vdout0_18ck75 = 0 time = 380
* CHECK dout0_19 vdout0_19ck75 = 3.3 time = 380
* CHECK dout0_20 vdout0_20ck75 = 0 time = 380
* CHECK dout0_21 vdout0_21ck75 = 0 time = 380
* CHECK dout0_22 vdout0_22ck75 = 3.3 time = 380
* CHECK dout0_23 vdout0_23ck75 = 3.3 time = 380
* CHECK dout0_24 vdout0_24ck75 = 0 time = 380
* CHECK dout0_25 vdout0_25ck75 = 3.3 time = 380
* CHECK dout0_26 vdout0_26ck75 = 0 time = 380
* CHECK dout0_27 vdout0_27ck75 = 0 time = 380
* CHECK dout0_28 vdout0_28ck75 = 3.3 time = 380
* CHECK dout0_29 vdout0_29ck75 = 0 time = 380
* CHECK dout0_30 vdout0_30ck75 = 3.3 time = 380
* CHECK dout0_31 vdout0_31ck75 = 3.3 time = 380
* CHECK dout0_0 vdout0_0ck76 = 3.3 time = 385
* CHECK dout0_1 vdout0_1ck76 = 3.3 time = 385
* CHECK dout0_2 vdout0_2ck76 = 0 time = 385
* CHECK dout0_3 vdout0_3ck76 = 3.3 time = 385
* CHECK dout0_4 vdout0_4ck76 = 3.3 time = 385
* CHECK dout0_5 vdout0_5ck76 = 3.3 time = 385
* CHECK dout0_6 vdout0_6ck76 = 3.3 time = 385
* CHECK dout0_7 vdout0_7ck76 = 3.3 time = 385
* CHECK dout0_8 vdout0_8ck76 = 3.3 time = 385
* CHECK dout0_9 vdout0_9ck76 = 0 time = 385
* CHECK dout0_10 vdout0_10ck76 = 0 time = 385
* CHECK dout0_11 vdout0_11ck76 = 3.3 time = 385
* CHECK dout0_12 vdout0_12ck76 = 3.3 time = 385
* CHECK dout0_13 vdout0_13ck76 = 3.3 time = 385
* CHECK dout0_14 vdout0_14ck76 = 0 time = 385
* CHECK dout0_15 vdout0_15ck76 = 3.3 time = 385
* CHECK dout0_16 vdout0_16ck76 = 3.3 time = 385
* CHECK dout0_17 vdout0_17ck76 = 3.3 time = 385
* CHECK dout0_18 vdout0_18ck76 = 0 time = 385
* CHECK dout0_19 vdout0_19ck76 = 3.3 time = 385
* CHECK dout0_20 vdout0_20ck76 = 0 time = 385
* CHECK dout0_21 vdout0_21ck76 = 0 time = 385
* CHECK dout0_22 vdout0_22ck76 = 3.3 time = 385
* CHECK dout0_23 vdout0_23ck76 = 3.3 time = 385
* CHECK dout0_24 vdout0_24ck76 = 0 time = 385
* CHECK dout0_25 vdout0_25ck76 = 3.3 time = 385
* CHECK dout0_26 vdout0_26ck76 = 0 time = 385
* CHECK dout0_27 vdout0_27ck76 = 0 time = 385
* CHECK dout0_28 vdout0_28ck76 = 3.3 time = 385
* CHECK dout0_29 vdout0_29ck76 = 0 time = 385
* CHECK dout0_30 vdout0_30ck76 = 3.3 time = 385
* CHECK dout0_31 vdout0_31ck76 = 3.3 time = 385
* CHECK dout0_0 vdout0_0ck77 = 3.3 time = 390
* CHECK dout0_1 vdout0_1ck77 = 3.3 time = 390
* CHECK dout0_2 vdout0_2ck77 = 0 time = 390
* CHECK dout0_3 vdout0_3ck77 = 3.3 time = 390
* CHECK dout0_4 vdout0_4ck77 = 3.3 time = 390
* CHECK dout0_5 vdout0_5ck77 = 3.3 time = 390
* CHECK dout0_6 vdout0_6ck77 = 3.3 time = 390
* CHECK dout0_7 vdout0_7ck77 = 3.3 time = 390
* CHECK dout0_8 vdout0_8ck77 = 3.3 time = 390
* CHECK dout0_9 vdout0_9ck77 = 0 time = 390
* CHECK dout0_10 vdout0_10ck77 = 0 time = 390
* CHECK dout0_11 vdout0_11ck77 = 3.3 time = 390
* CHECK dout0_12 vdout0_12ck77 = 3.3 time = 390
* CHECK dout0_13 vdout0_13ck77 = 3.3 time = 390
* CHECK dout0_14 vdout0_14ck77 = 0 time = 390
* CHECK dout0_15 vdout0_15ck77 = 3.3 time = 390
* CHECK dout0_16 vdout0_16ck77 = 3.3 time = 390
* CHECK dout0_17 vdout0_17ck77 = 3.3 time = 390
* CHECK dout0_18 vdout0_18ck77 = 0 time = 390
* CHECK dout0_19 vdout0_19ck77 = 3.3 time = 390
* CHECK dout0_20 vdout0_20ck77 = 0 time = 390
* CHECK dout0_21 vdout0_21ck77 = 0 time = 390
* CHECK dout0_22 vdout0_22ck77 = 3.3 time = 390
* CHECK dout0_23 vdout0_23ck77 = 3.3 time = 390
* CHECK dout0_24 vdout0_24ck77 = 0 time = 390
* CHECK dout0_25 vdout0_25ck77 = 3.3 time = 390
* CHECK dout0_26 vdout0_26ck77 = 0 time = 390
* CHECK dout0_27 vdout0_27ck77 = 0 time = 390
* CHECK dout0_28 vdout0_28ck77 = 3.3 time = 390
* CHECK dout0_29 vdout0_29ck77 = 0 time = 390
* CHECK dout0_30 vdout0_30ck77 = 3.3 time = 390
* CHECK dout0_31 vdout0_31ck77 = 3.3 time = 390
* CHECK dout0_0 vdout0_0ck81 = 3.3 time = 410
* CHECK dout0_1 vdout0_1ck81 = 3.3 time = 410
* CHECK dout0_2 vdout0_2ck81 = 0 time = 410
* CHECK dout0_3 vdout0_3ck81 = 3.3 time = 410
* CHECK dout0_4 vdout0_4ck81 = 3.3 time = 410
* CHECK dout0_5 vdout0_5ck81 = 3.3 time = 410
* CHECK dout0_6 vdout0_6ck81 = 3.3 time = 410
* CHECK dout0_7 vdout0_7ck81 = 3.3 time = 410
* CHECK dout0_8 vdout0_8ck81 = 3.3 time = 410
* CHECK dout0_9 vdout0_9ck81 = 0 time = 410
* CHECK dout0_10 vdout0_10ck81 = 0 time = 410
* CHECK dout0_11 vdout0_11ck81 = 3.3 time = 410
* CHECK dout0_12 vdout0_12ck81 = 3.3 time = 410
* CHECK dout0_13 vdout0_13ck81 = 3.3 time = 410
* CHECK dout0_14 vdout0_14ck81 = 0 time = 410
* CHECK dout0_15 vdout0_15ck81 = 3.3 time = 410
* CHECK dout0_16 vdout0_16ck81 = 3.3 time = 410
* CHECK dout0_17 vdout0_17ck81 = 3.3 time = 410
* CHECK dout0_18 vdout0_18ck81 = 0 time = 410
* CHECK dout0_19 vdout0_19ck81 = 3.3 time = 410
* CHECK dout0_20 vdout0_20ck81 = 0 time = 410
* CHECK dout0_21 vdout0_21ck81 = 0 time = 410
* CHECK dout0_22 vdout0_22ck81 = 3.3 time = 410
* CHECK dout0_23 vdout0_23ck81 = 3.3 time = 410
* CHECK dout0_24 vdout0_24ck81 = 0 time = 410
* CHECK dout0_25 vdout0_25ck81 = 3.3 time = 410
* CHECK dout0_26 vdout0_26ck81 = 0 time = 410
* CHECK dout0_27 vdout0_27ck81 = 0 time = 410
* CHECK dout0_28 vdout0_28ck81 = 3.3 time = 410
* CHECK dout0_29 vdout0_29ck81 = 0 time = 410
* CHECK dout0_30 vdout0_30ck81 = 3.3 time = 410
* CHECK dout0_31 vdout0_31ck81 = 3.3 time = 410
* CHECK dout0_0 vdout0_0ck84 = 0 time = 425
* CHECK dout0_1 vdout0_1ck84 = 0 time = 425
* CHECK dout0_2 vdout0_2ck84 = 0 time = 425
* CHECK dout0_3 vdout0_3ck84 = 0 time = 425
* CHECK dout0_4 vdout0_4ck84 = 3.3 time = 425
* CHECK dout0_5 vdout0_5ck84 = 0 time = 425
* CHECK dout0_6 vdout0_6ck84 = 3.3 time = 425
* CHECK dout0_7 vdout0_7ck84 = 3.3 time = 425
* CHECK dout0_8 vdout0_8ck84 = 0 time = 425
* CHECK dout0_9 vdout0_9ck84 = 0 time = 425
* CHECK dout0_10 vdout0_10ck84 = 3.3 time = 425
* CHECK dout0_11 vdout0_11ck84 = 3.3 time = 425
* CHECK dout0_12 vdout0_12ck84 = 0 time = 425
* CHECK dout0_13 vdout0_13ck84 = 3.3 time = 425
* CHECK dout0_14 vdout0_14ck84 = 0 time = 425
* CHECK dout0_15 vdout0_15ck84 = 3.3 time = 425
* CHECK dout0_16 vdout0_16ck84 = 0 time = 425
* CHECK dout0_17 vdout0_17ck84 = 3.3 time = 425
* CHECK dout0_18 vdout0_18ck84 = 3.3 time = 425
* CHECK dout0_19 vdout0_19ck84 = 0 time = 425
* CHECK dout0_20 vdout0_20ck84 = 0 time = 425
* CHECK dout0_21 vdout0_21ck84 = 0 time = 425
* CHECK dout0_22 vdout0_22ck84 = 0 time = 425
* CHECK dout0_23 vdout0_23ck84 = 3.3 time = 425
* CHECK dout0_24 vdout0_24ck84 = 3.3 time = 425
* CHECK dout0_25 vdout0_25ck84 = 3.3 time = 425
* CHECK dout0_26 vdout0_26ck84 = 3.3 time = 425
* CHECK dout0_27 vdout0_27ck84 = 3.3 time = 425
* CHECK dout0_28 vdout0_28ck84 = 3.3 time = 425
* CHECK dout0_29 vdout0_29ck84 = 3.3 time = 425
* CHECK dout0_30 vdout0_30ck84 = 3.3 time = 425
* CHECK dout0_31 vdout0_31ck84 = 3.3 time = 425
* CHECK dout0_0 vdout0_0ck85 = 3.3 time = 430
* CHECK dout0_1 vdout0_1ck85 = 0 time = 430
* CHECK dout0_2 vdout0_2ck85 = 3.3 time = 430
* CHECK dout0_3 vdout0_3ck85 = 3.3 time = 430
* CHECK dout0_4 vdout0_4ck85 = 3.3 time = 430
* CHECK dout0_5 vdout0_5ck85 = 0 time = 430
* CHECK dout0_6 vdout0_6ck85 = 3.3 time = 430
* CHECK dout0_7 vdout0_7ck85 = 3.3 time = 430
* CHECK dout0_8 vdout0_8ck85 = 3.3 time = 430
* CHECK dout0_9 vdout0_9ck85 = 0 time = 430
* CHECK dout0_10 vdout0_10ck85 = 0 time = 430
* CHECK dout0_11 vdout0_11ck85 = 3.3 time = 430
* CHECK dout0_12 vdout0_12ck85 = 0 time = 430
* CHECK dout0_13 vdout0_13ck85 = 0 time = 430
* CHECK dout0_14 vdout0_14ck85 = 0 time = 430
* CHECK dout0_15 vdout0_15ck85 = 3.3 time = 430
* CHECK dout0_16 vdout0_16ck85 = 0 time = 430
* CHECK dout0_17 vdout0_17ck85 = 0 time = 430
* CHECK dout0_18 vdout0_18ck85 = 0 time = 430
* CHECK dout0_19 vdout0_19ck85 = 3.3 time = 430
* CHECK dout0_20 vdout0_20ck85 = 3.3 time = 430
* CHECK dout0_21 vdout0_21ck85 = 3.3 time = 430
* CHECK dout0_22 vdout0_22ck85 = 3.3 time = 430
* CHECK dout0_23 vdout0_23ck85 = 0 time = 430
* CHECK dout0_24 vdout0_24ck85 = 0 time = 430
* CHECK dout0_25 vdout0_25ck85 = 0 time = 430
* CHECK dout0_26 vdout0_26ck85 = 0 time = 430
* CHECK dout0_27 vdout0_27ck85 = 0 time = 430
* CHECK dout0_28 vdout0_28ck85 = 3.3 time = 430
* CHECK dout0_29 vdout0_29ck85 = 3.3 time = 430
* CHECK dout0_30 vdout0_30ck85 = 3.3 time = 430
* CHECK dout0_31 vdout0_31ck85 = 3.3 time = 430
* CHECK dout0_0 vdout0_0ck86 = 0 time = 435
* CHECK dout0_1 vdout0_1ck86 = 0 time = 435
* CHECK dout0_2 vdout0_2ck86 = 0 time = 435
* CHECK dout0_3 vdout0_3ck86 = 0 time = 435
* CHECK dout0_4 vdout0_4ck86 = 3.3 time = 435
* CHECK dout0_5 vdout0_5ck86 = 0 time = 435
* CHECK dout0_6 vdout0_6ck86 = 3.3 time = 435
* CHECK dout0_7 vdout0_7ck86 = 3.3 time = 435
* CHECK dout0_8 vdout0_8ck86 = 0 time = 435
* CHECK dout0_9 vdout0_9ck86 = 0 time = 435
* CHECK dout0_10 vdout0_10ck86 = 3.3 time = 435
* CHECK dout0_11 vdout0_11ck86 = 3.3 time = 435
* CHECK dout0_12 vdout0_12ck86 = 0 time = 435
* CHECK dout0_13 vdout0_13ck86 = 3.3 time = 435
* CHECK dout0_14 vdout0_14ck86 = 0 time = 435
* CHECK dout0_15 vdout0_15ck86 = 3.3 time = 435
* CHECK dout0_16 vdout0_16ck86 = 0 time = 435
* CHECK dout0_17 vdout0_17ck86 = 3.3 time = 435
* CHECK dout0_18 vdout0_18ck86 = 3.3 time = 435
* CHECK dout0_19 vdout0_19ck86 = 0 time = 435
* CHECK dout0_20 vdout0_20ck86 = 0 time = 435
* CHECK dout0_21 vdout0_21ck86 = 0 time = 435
* CHECK dout0_22 vdout0_22ck86 = 0 time = 435
* CHECK dout0_23 vdout0_23ck86 = 3.3 time = 435
* CHECK dout0_24 vdout0_24ck86 = 3.3 time = 435
* CHECK dout0_25 vdout0_25ck86 = 3.3 time = 435
* CHECK dout0_26 vdout0_26ck86 = 3.3 time = 435
* CHECK dout0_27 vdout0_27ck86 = 3.3 time = 435
* CHECK dout0_28 vdout0_28ck86 = 3.3 time = 435
* CHECK dout0_29 vdout0_29ck86 = 3.3 time = 435
* CHECK dout0_30 vdout0_30ck86 = 3.3 time = 435
* CHECK dout0_31 vdout0_31ck86 = 3.3 time = 435
* CHECK dout0_0 vdout0_0ck88 = 3.3 time = 445
* CHECK dout0_1 vdout0_1ck88 = 0 time = 445
* CHECK dout0_2 vdout0_2ck88 = 3.3 time = 445
* CHECK dout0_3 vdout0_3ck88 = 3.3 time = 445
* CHECK dout0_4 vdout0_4ck88 = 3.3 time = 445
* CHECK dout0_5 vdout0_5ck88 = 0 time = 445
* CHECK dout0_6 vdout0_6ck88 = 3.3 time = 445
* CHECK dout0_7 vdout0_7ck88 = 3.3 time = 445
* CHECK dout0_8 vdout0_8ck88 = 3.3 time = 445
* CHECK dout0_9 vdout0_9ck88 = 0 time = 445
* CHECK dout0_10 vdout0_10ck88 = 0 time = 445
* CHECK dout0_11 vdout0_11ck88 = 3.3 time = 445
* CHECK dout0_12 vdout0_12ck88 = 0 time = 445
* CHECK dout0_13 vdout0_13ck88 = 0 time = 445
* CHECK dout0_14 vdout0_14ck88 = 0 time = 445
* CHECK dout0_15 vdout0_15ck88 = 3.3 time = 445
* CHECK dout0_16 vdout0_16ck88 = 0 time = 445
* CHECK dout0_17 vdout0_17ck88 = 0 time = 445
* CHECK dout0_18 vdout0_18ck88 = 0 time = 445
* CHECK dout0_19 vdout0_19ck88 = 3.3 time = 445
* CHECK dout0_20 vdout0_20ck88 = 3.3 time = 445
* CHECK dout0_21 vdout0_21ck88 = 3.3 time = 445
* CHECK dout0_22 vdout0_22ck88 = 3.3 time = 445
* CHECK dout0_23 vdout0_23ck88 = 0 time = 445
* CHECK dout0_24 vdout0_24ck88 = 0 time = 445
* CHECK dout0_25 vdout0_25ck88 = 0 time = 445
* CHECK dout0_26 vdout0_26ck88 = 0 time = 445
* CHECK dout0_27 vdout0_27ck88 = 0 time = 445
* CHECK dout0_28 vdout0_28ck88 = 3.3 time = 445
* CHECK dout0_29 vdout0_29ck88 = 3.3 time = 445
* CHECK dout0_30 vdout0_30ck88 = 3.3 time = 445
* CHECK dout0_31 vdout0_31ck88 = 3.3 time = 445
* CHECK dout0_0 vdout0_0ck95 = 0 time = 480
* CHECK dout0_1 vdout0_1ck95 = 3.3 time = 480
* CHECK dout0_2 vdout0_2ck95 = 0 time = 480
* CHECK dout0_3 vdout0_3ck95 = 0 time = 480
* CHECK dout0_4 vdout0_4ck95 = 0 time = 480
* CHECK dout0_5 vdout0_5ck95 = 0 time = 480
* CHECK dout0_6 vdout0_6ck95 = 0 time = 480
* CHECK dout0_7 vdout0_7ck95 = 0 time = 480
* CHECK dout0_8 vdout0_8ck95 = 0 time = 480
* CHECK dout0_9 vdout0_9ck95 = 3.3 time = 480
* CHECK dout0_10 vdout0_10ck95 = 3.3 time = 480
* CHECK dout0_11 vdout0_11ck95 = 0 time = 480
* CHECK dout0_12 vdout0_12ck95 = 3.3 time = 480
* CHECK dout0_13 vdout0_13ck95 = 0 time = 480
* CHECK dout0_14 vdout0_14ck95 = 3.3 time = 480
* CHECK dout0_15 vdout0_15ck95 = 0 time = 480
* CHECK dout0_16 vdout0_16ck95 = 3.3 time = 480
* CHECK dout0_17 vdout0_17ck95 = 0 time = 480
* CHECK dout0_18 vdout0_18ck95 = 0 time = 480
* CHECK dout0_19 vdout0_19ck95 = 0 time = 480
* CHECK dout0_20 vdout0_20ck95 = 0 time = 480
* CHECK dout0_21 vdout0_21ck95 = 0 time = 480
* CHECK dout0_22 vdout0_22ck95 = 0 time = 480
* CHECK dout0_23 vdout0_23ck95 = 3.3 time = 480
* CHECK dout0_24 vdout0_24ck95 = 0 time = 480
* CHECK dout0_25 vdout0_25ck95 = 0 time = 480
* CHECK dout0_26 vdout0_26ck95 = 0 time = 480
* CHECK dout0_27 vdout0_27ck95 = 3.3 time = 480
* CHECK dout0_28 vdout0_28ck95 = 3.3 time = 480
* CHECK dout0_29 vdout0_29ck95 = 3.3 time = 480
* CHECK dout0_30 vdout0_30ck95 = 3.3 time = 480
* CHECK dout0_31 vdout0_31ck95 = 0 time = 480
* CHECK dout0_0 vdout0_0ck99 = 0 time = 500
* CHECK dout0_1 vdout0_1ck99 = 3.3 time = 500
* CHECK dout0_2 vdout0_2ck99 = 0 time = 500
* CHECK dout0_3 vdout0_3ck99 = 0 time = 500
* CHECK dout0_4 vdout0_4ck99 = 0 time = 500
* CHECK dout0_5 vdout0_5ck99 = 0 time = 500
* CHECK dout0_6 vdout0_6ck99 = 0 time = 500
* CHECK dout0_7 vdout0_7ck99 = 0 time = 500
* CHECK dout0_8 vdout0_8ck99 = 0 time = 500
* CHECK dout0_9 vdout0_9ck99 = 3.3 time = 500
* CHECK dout0_10 vdout0_10ck99 = 3.3 time = 500
* CHECK dout0_11 vdout0_11ck99 = 0 time = 500
* CHECK dout0_12 vdout0_12ck99 = 3.3 time = 500
* CHECK dout0_13 vdout0_13ck99 = 0 time = 500
* CHECK dout0_14 vdout0_14ck99 = 3.3 time = 500
* CHECK dout0_15 vdout0_15ck99 = 0 time = 500
* CHECK dout0_16 vdout0_16ck99 = 3.3 time = 500
* CHECK dout0_17 vdout0_17ck99 = 0 time = 500
* CHECK dout0_18 vdout0_18ck99 = 0 time = 500
* CHECK dout0_19 vdout0_19ck99 = 0 time = 500
* CHECK dout0_20 vdout0_20ck99 = 0 time = 500
* CHECK dout0_21 vdout0_21ck99 = 0 time = 500
* CHECK dout0_22 vdout0_22ck99 = 0 time = 500
* CHECK dout0_23 vdout0_23ck99 = 3.3 time = 500
* CHECK dout0_24 vdout0_24ck99 = 0 time = 500
* CHECK dout0_25 vdout0_25ck99 = 0 time = 500
* CHECK dout0_26 vdout0_26ck99 = 0 time = 500
* CHECK dout0_27 vdout0_27ck99 = 3.3 time = 500
* CHECK dout0_28 vdout0_28ck99 = 3.3 time = 500
* CHECK dout0_29 vdout0_29ck99 = 3.3 time = 500
* CHECK dout0_30 vdout0_30ck99 = 3.3 time = 500
* CHECK dout0_31 vdout0_31ck99 = 0 time = 500
* CHECK dout0_0 vdout0_0ck100 = 0 time = 505
* CHECK dout0_1 vdout0_1ck100 = 3.3 time = 505
* CHECK dout0_2 vdout0_2ck100 = 0 time = 505
* CHECK dout0_3 vdout0_3ck100 = 0 time = 505
* CHECK dout0_4 vdout0_4ck100 = 0 time = 505
* CHECK dout0_5 vdout0_5ck100 = 0 time = 505
* CHECK dout0_6 vdout0_6ck100 = 0 time = 505
* CHECK dout0_7 vdout0_7ck100 = 0 time = 505
* CHECK dout0_8 vdout0_8ck100 = 0 time = 505
* CHECK dout0_9 vdout0_9ck100 = 3.3 time = 505
* CHECK dout0_10 vdout0_10ck100 = 3.3 time = 505
* CHECK dout0_11 vdout0_11ck100 = 0 time = 505
* CHECK dout0_12 vdout0_12ck100 = 3.3 time = 505
* CHECK dout0_13 vdout0_13ck100 = 0 time = 505
* CHECK dout0_14 vdout0_14ck100 = 3.3 time = 505
* CHECK dout0_15 vdout0_15ck100 = 0 time = 505
* CHECK dout0_16 vdout0_16ck100 = 3.3 time = 505
* CHECK dout0_17 vdout0_17ck100 = 0 time = 505
* CHECK dout0_18 vdout0_18ck100 = 0 time = 505
* CHECK dout0_19 vdout0_19ck100 = 0 time = 505
* CHECK dout0_20 vdout0_20ck100 = 0 time = 505
* CHECK dout0_21 vdout0_21ck100 = 0 time = 505
* CHECK dout0_22 vdout0_22ck100 = 0 time = 505
* CHECK dout0_23 vdout0_23ck100 = 3.3 time = 505
* CHECK dout0_24 vdout0_24ck100 = 0 time = 505
* CHECK dout0_25 vdout0_25ck100 = 0 time = 505
* CHECK dout0_26 vdout0_26ck100 = 0 time = 505
* CHECK dout0_27 vdout0_27ck100 = 3.3 time = 505
* CHECK dout0_28 vdout0_28ck100 = 3.3 time = 505
* CHECK dout0_29 vdout0_29ck100 = 3.3 time = 505
* CHECK dout0_30 vdout0_30ck100 = 3.3 time = 505
* CHECK dout0_31 vdout0_31ck100 = 0 time = 505
* CHECK dout0_0 vdout0_0ck103 = 0 time = 520
* CHECK dout0_1 vdout0_1ck103 = 3.3 time = 520
* CHECK dout0_2 vdout0_2ck103 = 0 time = 520
* CHECK dout0_3 vdout0_3ck103 = 0 time = 520
* CHECK dout0_4 vdout0_4ck103 = 0 time = 520
* CHECK dout0_5 vdout0_5ck103 = 0 time = 520
* CHECK dout0_6 vdout0_6ck103 = 0 time = 520
* CHECK dout0_7 vdout0_7ck103 = 0 time = 520
* CHECK dout0_8 vdout0_8ck103 = 0 time = 520
* CHECK dout0_9 vdout0_9ck103 = 3.3 time = 520
* CHECK dout0_10 vdout0_10ck103 = 3.3 time = 520
* CHECK dout0_11 vdout0_11ck103 = 0 time = 520
* CHECK dout0_12 vdout0_12ck103 = 3.3 time = 520
* CHECK dout0_13 vdout0_13ck103 = 0 time = 520
* CHECK dout0_14 vdout0_14ck103 = 3.3 time = 520
* CHECK dout0_15 vdout0_15ck103 = 0 time = 520
* CHECK dout0_16 vdout0_16ck103 = 3.3 time = 520
* CHECK dout0_17 vdout0_17ck103 = 0 time = 520
* CHECK dout0_18 vdout0_18ck103 = 0 time = 520
* CHECK dout0_19 vdout0_19ck103 = 0 time = 520
* CHECK dout0_20 vdout0_20ck103 = 0 time = 520
* CHECK dout0_21 vdout0_21ck103 = 0 time = 520
* CHECK dout0_22 vdout0_22ck103 = 0 time = 520
* CHECK dout0_23 vdout0_23ck103 = 3.3 time = 520
* CHECK dout0_24 vdout0_24ck103 = 0 time = 520
* CHECK dout0_25 vdout0_25ck103 = 0 time = 520
* CHECK dout0_26 vdout0_26ck103 = 0 time = 520
* CHECK dout0_27 vdout0_27ck103 = 3.3 time = 520
* CHECK dout0_28 vdout0_28ck103 = 3.3 time = 520
* CHECK dout0_29 vdout0_29ck103 = 3.3 time = 520
* CHECK dout0_30 vdout0_30ck103 = 3.3 time = 520
* CHECK dout0_31 vdout0_31ck103 = 0 time = 520
* CHECK dout0_0 vdout0_0ck104 = 0 time = 525
* CHECK dout0_1 vdout0_1ck104 = 3.3 time = 525
* CHECK dout0_2 vdout0_2ck104 = 0 time = 525
* CHECK dout0_3 vdout0_3ck104 = 3.3 time = 525
* CHECK dout0_4 vdout0_4ck104 = 3.3 time = 525
* CHECK dout0_5 vdout0_5ck104 = 0 time = 525
* CHECK dout0_6 vdout0_6ck104 = 3.3 time = 525
* CHECK dout0_7 vdout0_7ck104 = 3.3 time = 525
* CHECK dout0_8 vdout0_8ck104 = 0 time = 525
* CHECK dout0_9 vdout0_9ck104 = 3.3 time = 525
* CHECK dout0_10 vdout0_10ck104 = 0 time = 525
* CHECK dout0_11 vdout0_11ck104 = 3.3 time = 525
* CHECK dout0_12 vdout0_12ck104 = 0 time = 525
* CHECK dout0_13 vdout0_13ck104 = 3.3 time = 525
* CHECK dout0_14 vdout0_14ck104 = 0 time = 525
* CHECK dout0_15 vdout0_15ck104 = 3.3 time = 525
* CHECK dout0_16 vdout0_16ck104 = 0 time = 525
* CHECK dout0_17 vdout0_17ck104 = 3.3 time = 525
* CHECK dout0_18 vdout0_18ck104 = 3.3 time = 525
* CHECK dout0_19 vdout0_19ck104 = 0 time = 525
* CHECK dout0_20 vdout0_20ck104 = 0 time = 525
* CHECK dout0_21 vdout0_21ck104 = 3.3 time = 525
* CHECK dout0_22 vdout0_22ck104 = 3.3 time = 525
* CHECK dout0_23 vdout0_23ck104 = 0 time = 525
* CHECK dout0_24 vdout0_24ck104 = 3.3 time = 525
* CHECK dout0_25 vdout0_25ck104 = 0 time = 525
* CHECK dout0_26 vdout0_26ck104 = 3.3 time = 525
* CHECK dout0_27 vdout0_27ck104 = 3.3 time = 525
* CHECK dout0_28 vdout0_28ck104 = 3.3 time = 525
* CHECK dout0_29 vdout0_29ck104 = 0 time = 525
* CHECK dout0_30 vdout0_30ck104 = 0 time = 525
* CHECK dout0_31 vdout0_31ck104 = 0 time = 525
* CHECK dout0_0 vdout0_0ck105 = 0 time = 530
* CHECK dout0_1 vdout0_1ck105 = 3.3 time = 530
* CHECK dout0_2 vdout0_2ck105 = 0 time = 530
* CHECK dout0_3 vdout0_3ck105 = 3.3 time = 530
* CHECK dout0_4 vdout0_4ck105 = 3.3 time = 530
* CHECK dout0_5 vdout0_5ck105 = 0 time = 530
* CHECK dout0_6 vdout0_6ck105 = 3.3 time = 530
* CHECK dout0_7 vdout0_7ck105 = 3.3 time = 530
* CHECK dout0_8 vdout0_8ck105 = 0 time = 530
* CHECK dout0_9 vdout0_9ck105 = 3.3 time = 530
* CHECK dout0_10 vdout0_10ck105 = 0 time = 530
* CHECK dout0_11 vdout0_11ck105 = 3.3 time = 530
* CHECK dout0_12 vdout0_12ck105 = 0 time = 530
* CHECK dout0_13 vdout0_13ck105 = 3.3 time = 530
* CHECK dout0_14 vdout0_14ck105 = 0 time = 530
* CHECK dout0_15 vdout0_15ck105 = 3.3 time = 530
* CHECK dout0_16 vdout0_16ck105 = 0 time = 530
* CHECK dout0_17 vdout0_17ck105 = 3.3 time = 530
* CHECK dout0_18 vdout0_18ck105 = 3.3 time = 530
* CHECK dout0_19 vdout0_19ck105 = 0 time = 530
* CHECK dout0_20 vdout0_20ck105 = 0 time = 530
* CHECK dout0_21 vdout0_21ck105 = 3.3 time = 530
* CHECK dout0_22 vdout0_22ck105 = 3.3 time = 530
* CHECK dout0_23 vdout0_23ck105 = 0 time = 530
* CHECK dout0_24 vdout0_24ck105 = 3.3 time = 530
* CHECK dout0_25 vdout0_25ck105 = 0 time = 530
* CHECK dout0_26 vdout0_26ck105 = 3.3 time = 530
* CHECK dout0_27 vdout0_27ck105 = 3.3 time = 530
* CHECK dout0_28 vdout0_28ck105 = 3.3 time = 530
* CHECK dout0_29 vdout0_29ck105 = 0 time = 530
* CHECK dout0_30 vdout0_30ck105 = 0 time = 530
* CHECK dout0_31 vdout0_31ck105 = 0 time = 530
* CHECK dout0_0 vdout0_0ck108 = 0 time = 545
* CHECK dout0_1 vdout0_1ck108 = 3.3 time = 545
* CHECK dout0_2 vdout0_2ck108 = 0 time = 545
* CHECK dout0_3 vdout0_3ck108 = 0 time = 545
* CHECK dout0_4 vdout0_4ck108 = 0 time = 545
* CHECK dout0_5 vdout0_5ck108 = 0 time = 545
* CHECK dout0_6 vdout0_6ck108 = 0 time = 545
* CHECK dout0_7 vdout0_7ck108 = 0 time = 545
* CHECK dout0_8 vdout0_8ck108 = 0 time = 545
* CHECK dout0_9 vdout0_9ck108 = 3.3 time = 545
* CHECK dout0_10 vdout0_10ck108 = 3.3 time = 545
* CHECK dout0_11 vdout0_11ck108 = 0 time = 545
* CHECK dout0_12 vdout0_12ck108 = 3.3 time = 545
* CHECK dout0_13 vdout0_13ck108 = 0 time = 545
* CHECK dout0_14 vdout0_14ck108 = 3.3 time = 545
* CHECK dout0_15 vdout0_15ck108 = 0 time = 545
* CHECK dout0_16 vdout0_16ck108 = 3.3 time = 545
* CHECK dout0_17 vdout0_17ck108 = 0 time = 545
* CHECK dout0_18 vdout0_18ck108 = 0 time = 545
* CHECK dout0_19 vdout0_19ck108 = 0 time = 545
* CHECK dout0_20 vdout0_20ck108 = 0 time = 545
* CHECK dout0_21 vdout0_21ck108 = 0 time = 545
* CHECK dout0_22 vdout0_22ck108 = 0 time = 545
* CHECK dout0_23 vdout0_23ck108 = 3.3 time = 545
* CHECK dout0_24 vdout0_24ck108 = 0 time = 545
* CHECK dout0_25 vdout0_25ck108 = 0 time = 545
* CHECK dout0_26 vdout0_26ck108 = 0 time = 545
* CHECK dout0_27 vdout0_27ck108 = 3.3 time = 545
* CHECK dout0_28 vdout0_28ck108 = 3.3 time = 545
* CHECK dout0_29 vdout0_29ck108 = 3.3 time = 545
* CHECK dout0_30 vdout0_30ck108 = 3.3 time = 545
* CHECK dout0_31 vdout0_31ck108 = 0 time = 545
* CHECK dout0_0 vdout0_0ck110 = 3.3 time = 555
* CHECK dout0_1 vdout0_1ck110 = 3.3 time = 555
* CHECK dout0_2 vdout0_2ck110 = 0 time = 555
* CHECK dout0_3 vdout0_3ck110 = 3.3 time = 555
* CHECK dout0_4 vdout0_4ck110 = 0 time = 555
* CHECK dout0_5 vdout0_5ck110 = 3.3 time = 555
* CHECK dout0_6 vdout0_6ck110 = 3.3 time = 555
* CHECK dout0_7 vdout0_7ck110 = 3.3 time = 555
* CHECK dout0_8 vdout0_8ck110 = 3.3 time = 555
* CHECK dout0_9 vdout0_9ck110 = 3.3 time = 555
* CHECK dout0_10 vdout0_10ck110 = 0 time = 555
* CHECK dout0_11 vdout0_11ck110 = 0 time = 555
* CHECK dout0_12 vdout0_12ck110 = 3.3 time = 555
* CHECK dout0_13 vdout0_13ck110 = 3.3 time = 555
* CHECK dout0_14 vdout0_14ck110 = 3.3 time = 555
* CHECK dout0_15 vdout0_15ck110 = 3.3 time = 555
* CHECK dout0_16 vdout0_16ck110 = 3.3 time = 555
* CHECK dout0_17 vdout0_17ck110 = 3.3 time = 555
* CHECK dout0_18 vdout0_18ck110 = 3.3 time = 555
* CHECK dout0_19 vdout0_19ck110 = 0 time = 555
* CHECK dout0_20 vdout0_20ck110 = 0 time = 555
* CHECK dout0_21 vdout0_21ck110 = 0 time = 555
* CHECK dout0_22 vdout0_22ck110 = 0 time = 555
* CHECK dout0_23 vdout0_23ck110 = 0 time = 555
* CHECK dout0_24 vdout0_24ck110 = 0 time = 555
* CHECK dout0_25 vdout0_25ck110 = 0 time = 555
* CHECK dout0_26 vdout0_26ck110 = 3.3 time = 555
* CHECK dout0_27 vdout0_27ck110 = 3.3 time = 555
* CHECK dout0_28 vdout0_28ck110 = 3.3 time = 555
* CHECK dout0_29 vdout0_29ck110 = 3.3 time = 555
* CHECK dout0_30 vdout0_30ck110 = 0 time = 555
* CHECK dout0_31 vdout0_31ck110 = 3.3 time = 555
* CHECK dout0_0 vdout0_0ck111 = 3.3 time = 560
* CHECK dout0_1 vdout0_1ck111 = 3.3 time = 560
* CHECK dout0_2 vdout0_2ck111 = 0 time = 560
* CHECK dout0_3 vdout0_3ck111 = 3.3 time = 560
* CHECK dout0_4 vdout0_4ck111 = 0 time = 560
* CHECK dout0_5 vdout0_5ck111 = 3.3 time = 560
* CHECK dout0_6 vdout0_6ck111 = 3.3 time = 560
* CHECK dout0_7 vdout0_7ck111 = 3.3 time = 560
* CHECK dout0_8 vdout0_8ck111 = 3.3 time = 560
* CHECK dout0_9 vdout0_9ck111 = 3.3 time = 560
* CHECK dout0_10 vdout0_10ck111 = 0 time = 560
* CHECK dout0_11 vdout0_11ck111 = 0 time = 560
* CHECK dout0_12 vdout0_12ck111 = 3.3 time = 560
* CHECK dout0_13 vdout0_13ck111 = 3.3 time = 560
* CHECK dout0_14 vdout0_14ck111 = 3.3 time = 560
* CHECK dout0_15 vdout0_15ck111 = 3.3 time = 560
* CHECK dout0_16 vdout0_16ck111 = 3.3 time = 560
* CHECK dout0_17 vdout0_17ck111 = 3.3 time = 560
* CHECK dout0_18 vdout0_18ck111 = 3.3 time = 560
* CHECK dout0_19 vdout0_19ck111 = 0 time = 560
* CHECK dout0_20 vdout0_20ck111 = 0 time = 560
* CHECK dout0_21 vdout0_21ck111 = 0 time = 560
* CHECK dout0_22 vdout0_22ck111 = 0 time = 560
* CHECK dout0_23 vdout0_23ck111 = 0 time = 560
* CHECK dout0_24 vdout0_24ck111 = 0 time = 560
* CHECK dout0_25 vdout0_25ck111 = 0 time = 560
* CHECK dout0_26 vdout0_26ck111 = 3.3 time = 560
* CHECK dout0_27 vdout0_27ck111 = 3.3 time = 560
* CHECK dout0_28 vdout0_28ck111 = 3.3 time = 560
* CHECK dout0_29 vdout0_29ck111 = 3.3 time = 560
* CHECK dout0_30 vdout0_30ck111 = 0 time = 560
* CHECK dout0_31 vdout0_31ck111 = 3.3 time = 560
* CHECK dout0_0 vdout0_0ck114 = 0 time = 575
* CHECK dout0_1 vdout0_1ck114 = 3.3 time = 575
* CHECK dout0_2 vdout0_2ck114 = 3.3 time = 575
* CHECK dout0_3 vdout0_3ck114 = 0 time = 575
* CHECK dout0_4 vdout0_4ck114 = 0 time = 575
* CHECK dout0_5 vdout0_5ck114 = 3.3 time = 575
* CHECK dout0_6 vdout0_6ck114 = 0 time = 575
* CHECK dout0_7 vdout0_7ck114 = 0 time = 575
* CHECK dout0_8 vdout0_8ck114 = 3.3 time = 575
* CHECK dout0_9 vdout0_9ck114 = 0 time = 575
* CHECK dout0_10 vdout0_10ck114 = 0 time = 575
* CHECK dout0_11 vdout0_11ck114 = 0 time = 575
* CHECK dout0_12 vdout0_12ck114 = 0 time = 575
* CHECK dout0_13 vdout0_13ck114 = 3.3 time = 575
* CHECK dout0_14 vdout0_14ck114 = 3.3 time = 575
* CHECK dout0_15 vdout0_15ck114 = 0 time = 575
* CHECK dout0_16 vdout0_16ck114 = 0 time = 575
* CHECK dout0_17 vdout0_17ck114 = 0 time = 575
* CHECK dout0_18 vdout0_18ck114 = 3.3 time = 575
* CHECK dout0_19 vdout0_19ck114 = 3.3 time = 575
* CHECK dout0_20 vdout0_20ck114 = 0 time = 575
* CHECK dout0_21 vdout0_21ck114 = 3.3 time = 575
* CHECK dout0_22 vdout0_22ck114 = 0 time = 575
* CHECK dout0_23 vdout0_23ck114 = 0 time = 575
* CHECK dout0_24 vdout0_24ck114 = 0 time = 575
* CHECK dout0_25 vdout0_25ck114 = 0 time = 575
* CHECK dout0_26 vdout0_26ck114 = 3.3 time = 575
* CHECK dout0_27 vdout0_27ck114 = 3.3 time = 575
* CHECK dout0_28 vdout0_28ck114 = 0 time = 575
* CHECK dout0_29 vdout0_29ck114 = 3.3 time = 575
* CHECK dout0_30 vdout0_30ck114 = 0 time = 575
* CHECK dout0_31 vdout0_31ck114 = 0 time = 575
* CHECK dout0_0 vdout0_0ck117 = 0 time = 590
* CHECK dout0_1 vdout0_1ck117 = 3.3 time = 590
* CHECK dout0_2 vdout0_2ck117 = 0 time = 590
* CHECK dout0_3 vdout0_3ck117 = 0 time = 590
* CHECK dout0_4 vdout0_4ck117 = 0 time = 590
* CHECK dout0_5 vdout0_5ck117 = 0 time = 590
* CHECK dout0_6 vdout0_6ck117 = 0 time = 590
* CHECK dout0_7 vdout0_7ck117 = 0 time = 590
* CHECK dout0_8 vdout0_8ck117 = 0 time = 590
* CHECK dout0_9 vdout0_9ck117 = 3.3 time = 590
* CHECK dout0_10 vdout0_10ck117 = 3.3 time = 590
* CHECK dout0_11 vdout0_11ck117 = 0 time = 590
* CHECK dout0_12 vdout0_12ck117 = 3.3 time = 590
* CHECK dout0_13 vdout0_13ck117 = 0 time = 590
* CHECK dout0_14 vdout0_14ck117 = 3.3 time = 590
* CHECK dout0_15 vdout0_15ck117 = 0 time = 590
* CHECK dout0_16 vdout0_16ck117 = 3.3 time = 590
* CHECK dout0_17 vdout0_17ck117 = 0 time = 590
* CHECK dout0_18 vdout0_18ck117 = 0 time = 590
* CHECK dout0_19 vdout0_19ck117 = 0 time = 590
* CHECK dout0_20 vdout0_20ck117 = 0 time = 590
* CHECK dout0_21 vdout0_21ck117 = 0 time = 590
* CHECK dout0_22 vdout0_22ck117 = 0 time = 590
* CHECK dout0_23 vdout0_23ck117 = 3.3 time = 590
* CHECK dout0_24 vdout0_24ck117 = 0 time = 590
* CHECK dout0_25 vdout0_25ck117 = 0 time = 590
* CHECK dout0_26 vdout0_26ck117 = 0 time = 590
* CHECK dout0_27 vdout0_27ck117 = 3.3 time = 590
* CHECK dout0_28 vdout0_28ck117 = 3.3 time = 590
* CHECK dout0_29 vdout0_29ck117 = 3.3 time = 590
* CHECK dout0_30 vdout0_30ck117 = 3.3 time = 590
* CHECK dout0_31 vdout0_31ck117 = 0 time = 590
* CHECK dout0_0 vdout0_0ck118 = 0 time = 595
* CHECK dout0_1 vdout0_1ck118 = 3.3 time = 595
* CHECK dout0_2 vdout0_2ck118 = 0 time = 595
* CHECK dout0_3 vdout0_3ck118 = 0 time = 595
* CHECK dout0_4 vdout0_4ck118 = 0 time = 595
* CHECK dout0_5 vdout0_5ck118 = 0 time = 595
* CHECK dout0_6 vdout0_6ck118 = 0 time = 595
* CHECK dout0_7 vdout0_7ck118 = 0 time = 595
* CHECK dout0_8 vdout0_8ck118 = 0 time = 595
* CHECK dout0_9 vdout0_9ck118 = 3.3 time = 595
* CHECK dout0_10 vdout0_10ck118 = 3.3 time = 595
* CHECK dout0_11 vdout0_11ck118 = 0 time = 595
* CHECK dout0_12 vdout0_12ck118 = 3.3 time = 595
* CHECK dout0_13 vdout0_13ck118 = 0 time = 595
* CHECK dout0_14 vdout0_14ck118 = 3.3 time = 595
* CHECK dout0_15 vdout0_15ck118 = 0 time = 595
* CHECK dout0_16 vdout0_16ck118 = 3.3 time = 595
* CHECK dout0_17 vdout0_17ck118 = 0 time = 595
* CHECK dout0_18 vdout0_18ck118 = 0 time = 595
* CHECK dout0_19 vdout0_19ck118 = 0 time = 595
* CHECK dout0_20 vdout0_20ck118 = 0 time = 595
* CHECK dout0_21 vdout0_21ck118 = 0 time = 595
* CHECK dout0_22 vdout0_22ck118 = 0 time = 595
* CHECK dout0_23 vdout0_23ck118 = 3.3 time = 595
* CHECK dout0_24 vdout0_24ck118 = 0 time = 595
* CHECK dout0_25 vdout0_25ck118 = 0 time = 595
* CHECK dout0_26 vdout0_26ck118 = 0 time = 595
* CHECK dout0_27 vdout0_27ck118 = 3.3 time = 595
* CHECK dout0_28 vdout0_28ck118 = 3.3 time = 595
* CHECK dout0_29 vdout0_29ck118 = 3.3 time = 595
* CHECK dout0_30 vdout0_30ck118 = 3.3 time = 595
* CHECK dout0_31 vdout0_31ck118 = 0 time = 595
* CHECK dout0_0 vdout0_0ck119 = 0 time = 600
* CHECK dout0_1 vdout0_1ck119 = 3.3 time = 600
* CHECK dout0_2 vdout0_2ck119 = 0 time = 600
* CHECK dout0_3 vdout0_3ck119 = 0 time = 600
* CHECK dout0_4 vdout0_4ck119 = 0 time = 600
* CHECK dout0_5 vdout0_5ck119 = 0 time = 600
* CHECK dout0_6 vdout0_6ck119 = 0 time = 600
* CHECK dout0_7 vdout0_7ck119 = 0 time = 600
* CHECK dout0_8 vdout0_8ck119 = 0 time = 600
* CHECK dout0_9 vdout0_9ck119 = 3.3 time = 600
* CHECK dout0_10 vdout0_10ck119 = 3.3 time = 600
* CHECK dout0_11 vdout0_11ck119 = 0 time = 600
* CHECK dout0_12 vdout0_12ck119 = 3.3 time = 600
* CHECK dout0_13 vdout0_13ck119 = 0 time = 600
* CHECK dout0_14 vdout0_14ck119 = 3.3 time = 600
* CHECK dout0_15 vdout0_15ck119 = 0 time = 600
* CHECK dout0_16 vdout0_16ck119 = 3.3 time = 600
* CHECK dout0_17 vdout0_17ck119 = 0 time = 600
* CHECK dout0_18 vdout0_18ck119 = 0 time = 600
* CHECK dout0_19 vdout0_19ck119 = 0 time = 600
* CHECK dout0_20 vdout0_20ck119 = 0 time = 600
* CHECK dout0_21 vdout0_21ck119 = 0 time = 600
* CHECK dout0_22 vdout0_22ck119 = 0 time = 600
* CHECK dout0_23 vdout0_23ck119 = 3.3 time = 600
* CHECK dout0_24 vdout0_24ck119 = 0 time = 600
* CHECK dout0_25 vdout0_25ck119 = 0 time = 600
* CHECK dout0_26 vdout0_26ck119 = 0 time = 600
* CHECK dout0_27 vdout0_27ck119 = 3.3 time = 600
* CHECK dout0_28 vdout0_28ck119 = 3.3 time = 600
* CHECK dout0_29 vdout0_29ck119 = 3.3 time = 600
* CHECK dout0_30 vdout0_30ck119 = 3.3 time = 600
* CHECK dout0_31 vdout0_31ck119 = 0 time = 600
* CHECK dout0_0 vdout0_0ck120 = 0 time = 605
* CHECK dout0_1 vdout0_1ck120 = 3.3 time = 605
* CHECK dout0_2 vdout0_2ck120 = 0 time = 605
* CHECK dout0_3 vdout0_3ck120 = 0 time = 605
* CHECK dout0_4 vdout0_4ck120 = 0 time = 605
* CHECK dout0_5 vdout0_5ck120 = 0 time = 605
* CHECK dout0_6 vdout0_6ck120 = 0 time = 605
* CHECK dout0_7 vdout0_7ck120 = 0 time = 605
* CHECK dout0_8 vdout0_8ck120 = 0 time = 605
* CHECK dout0_9 vdout0_9ck120 = 3.3 time = 605
* CHECK dout0_10 vdout0_10ck120 = 3.3 time = 605
* CHECK dout0_11 vdout0_11ck120 = 0 time = 605
* CHECK dout0_12 vdout0_12ck120 = 3.3 time = 605
* CHECK dout0_13 vdout0_13ck120 = 0 time = 605
* CHECK dout0_14 vdout0_14ck120 = 3.3 time = 605
* CHECK dout0_15 vdout0_15ck120 = 0 time = 605
* CHECK dout0_16 vdout0_16ck120 = 3.3 time = 605
* CHECK dout0_17 vdout0_17ck120 = 0 time = 605
* CHECK dout0_18 vdout0_18ck120 = 0 time = 605
* CHECK dout0_19 vdout0_19ck120 = 0 time = 605
* CHECK dout0_20 vdout0_20ck120 = 0 time = 605
* CHECK dout0_21 vdout0_21ck120 = 0 time = 605
* CHECK dout0_22 vdout0_22ck120 = 0 time = 605
* CHECK dout0_23 vdout0_23ck120 = 3.3 time = 605
* CHECK dout0_24 vdout0_24ck120 = 0 time = 605
* CHECK dout0_25 vdout0_25ck120 = 0 time = 605
* CHECK dout0_26 vdout0_26ck120 = 0 time = 605
* CHECK dout0_27 vdout0_27ck120 = 3.3 time = 605
* CHECK dout0_28 vdout0_28ck120 = 3.3 time = 605
* CHECK dout0_29 vdout0_29ck120 = 3.3 time = 605
* CHECK dout0_30 vdout0_30ck120 = 3.3 time = 605
* CHECK dout0_31 vdout0_31ck120 = 0 time = 605
* CHECK dout0_0 vdout0_0ck121 = 0 time = 610
* CHECK dout0_1 vdout0_1ck121 = 3.3 time = 610
* CHECK dout0_2 vdout0_2ck121 = 0 time = 610
* CHECK dout0_3 vdout0_3ck121 = 0 time = 610
* CHECK dout0_4 vdout0_4ck121 = 0 time = 610
* CHECK dout0_5 vdout0_5ck121 = 0 time = 610
* CHECK dout0_6 vdout0_6ck121 = 0 time = 610
* CHECK dout0_7 vdout0_7ck121 = 0 time = 610
* CHECK dout0_8 vdout0_8ck121 = 0 time = 610
* CHECK dout0_9 vdout0_9ck121 = 3.3 time = 610
* CHECK dout0_10 vdout0_10ck121 = 3.3 time = 610
* CHECK dout0_11 vdout0_11ck121 = 0 time = 610
* CHECK dout0_12 vdout0_12ck121 = 3.3 time = 610
* CHECK dout0_13 vdout0_13ck121 = 0 time = 610
* CHECK dout0_14 vdout0_14ck121 = 3.3 time = 610
* CHECK dout0_15 vdout0_15ck121 = 0 time = 610
* CHECK dout0_16 vdout0_16ck121 = 3.3 time = 610
* CHECK dout0_17 vdout0_17ck121 = 0 time = 610
* CHECK dout0_18 vdout0_18ck121 = 0 time = 610
* CHECK dout0_19 vdout0_19ck121 = 0 time = 610
* CHECK dout0_20 vdout0_20ck121 = 0 time = 610
* CHECK dout0_21 vdout0_21ck121 = 0 time = 610
* CHECK dout0_22 vdout0_22ck121 = 0 time = 610
* CHECK dout0_23 vdout0_23ck121 = 3.3 time = 610
* CHECK dout0_24 vdout0_24ck121 = 0 time = 610
* CHECK dout0_25 vdout0_25ck121 = 0 time = 610
* CHECK dout0_26 vdout0_26ck121 = 0 time = 610
* CHECK dout0_27 vdout0_27ck121 = 3.3 time = 610
* CHECK dout0_28 vdout0_28ck121 = 3.3 time = 610
* CHECK dout0_29 vdout0_29ck121 = 3.3 time = 610
* CHECK dout0_30 vdout0_30ck121 = 3.3 time = 610
* CHECK dout0_31 vdout0_31ck121 = 0 time = 610
* CHECK dout0_0 vdout0_0ck122 = 0 time = 615
* CHECK dout0_1 vdout0_1ck122 = 3.3 time = 615
* CHECK dout0_2 vdout0_2ck122 = 0 time = 615
* CHECK dout0_3 vdout0_3ck122 = 0 time = 615
* CHECK dout0_4 vdout0_4ck122 = 0 time = 615
* CHECK dout0_5 vdout0_5ck122 = 0 time = 615
* CHECK dout0_6 vdout0_6ck122 = 0 time = 615
* CHECK dout0_7 vdout0_7ck122 = 0 time = 615
* CHECK dout0_8 vdout0_8ck122 = 0 time = 615
* CHECK dout0_9 vdout0_9ck122 = 3.3 time = 615
* CHECK dout0_10 vdout0_10ck122 = 3.3 time = 615
* CHECK dout0_11 vdout0_11ck122 = 0 time = 615
* CHECK dout0_12 vdout0_12ck122 = 3.3 time = 615
* CHECK dout0_13 vdout0_13ck122 = 0 time = 615
* CHECK dout0_14 vdout0_14ck122 = 3.3 time = 615
* CHECK dout0_15 vdout0_15ck122 = 0 time = 615
* CHECK dout0_16 vdout0_16ck122 = 3.3 time = 615
* CHECK dout0_17 vdout0_17ck122 = 0 time = 615
* CHECK dout0_18 vdout0_18ck122 = 0 time = 615
* CHECK dout0_19 vdout0_19ck122 = 0 time = 615
* CHECK dout0_20 vdout0_20ck122 = 0 time = 615
* CHECK dout0_21 vdout0_21ck122 = 0 time = 615
* CHECK dout0_22 vdout0_22ck122 = 0 time = 615
* CHECK dout0_23 vdout0_23ck122 = 3.3 time = 615
* CHECK dout0_24 vdout0_24ck122 = 0 time = 615
* CHECK dout0_25 vdout0_25ck122 = 0 time = 615
* CHECK dout0_26 vdout0_26ck122 = 0 time = 615
* CHECK dout0_27 vdout0_27ck122 = 3.3 time = 615
* CHECK dout0_28 vdout0_28ck122 = 3.3 time = 615
* CHECK dout0_29 vdout0_29ck122 = 3.3 time = 615
* CHECK dout0_30 vdout0_30ck122 = 3.3 time = 615
* CHECK dout0_31 vdout0_31ck122 = 0 time = 615
* CHECK dout0_0 vdout0_0ck125 = 0 time = 630
* CHECK dout0_1 vdout0_1ck125 = 3.3 time = 630
* CHECK dout0_2 vdout0_2ck125 = 3.3 time = 630
* CHECK dout0_3 vdout0_3ck125 = 0 time = 630
* CHECK dout0_4 vdout0_4ck125 = 0 time = 630
* CHECK dout0_5 vdout0_5ck125 = 3.3 time = 630
* CHECK dout0_6 vdout0_6ck125 = 0 time = 630
* CHECK dout0_7 vdout0_7ck125 = 0 time = 630
* CHECK dout0_8 vdout0_8ck125 = 3.3 time = 630
* CHECK dout0_9 vdout0_9ck125 = 0 time = 630
* CHECK dout0_10 vdout0_10ck125 = 0 time = 630
* CHECK dout0_11 vdout0_11ck125 = 0 time = 630
* CHECK dout0_12 vdout0_12ck125 = 0 time = 630
* CHECK dout0_13 vdout0_13ck125 = 3.3 time = 630
* CHECK dout0_14 vdout0_14ck125 = 3.3 time = 630
* CHECK dout0_15 vdout0_15ck125 = 0 time = 630
* CHECK dout0_16 vdout0_16ck125 = 0 time = 630
* CHECK dout0_17 vdout0_17ck125 = 0 time = 630
* CHECK dout0_18 vdout0_18ck125 = 3.3 time = 630
* CHECK dout0_19 vdout0_19ck125 = 3.3 time = 630
* CHECK dout0_20 vdout0_20ck125 = 0 time = 630
* CHECK dout0_21 vdout0_21ck125 = 3.3 time = 630
* CHECK dout0_22 vdout0_22ck125 = 0 time = 630
* CHECK dout0_23 vdout0_23ck125 = 0 time = 630
* CHECK dout0_24 vdout0_24ck125 = 0 time = 630
* CHECK dout0_25 vdout0_25ck125 = 0 time = 630
* CHECK dout0_26 vdout0_26ck125 = 3.3 time = 630
* CHECK dout0_27 vdout0_27ck125 = 3.3 time = 630
* CHECK dout0_28 vdout0_28ck125 = 0 time = 630
* CHECK dout0_29 vdout0_29ck125 = 3.3 time = 630
* CHECK dout0_30 vdout0_30ck125 = 0 time = 630
* CHECK dout0_31 vdout0_31ck125 = 0 time = 630
* CHECK dout0_0 vdout0_0ck132 = 0 time = 665
* CHECK dout0_1 vdout0_1ck132 = 0 time = 665
* CHECK dout0_2 vdout0_2ck132 = 0 time = 665
* CHECK dout0_3 vdout0_3ck132 = 3.3 time = 665
* CHECK dout0_4 vdout0_4ck132 = 3.3 time = 665
* CHECK dout0_5 vdout0_5ck132 = 0 time = 665
* CHECK dout0_6 vdout0_6ck132 = 0 time = 665
* CHECK dout0_7 vdout0_7ck132 = 0 time = 665
* CHECK dout0_8 vdout0_8ck132 = 0 time = 665
* CHECK dout0_9 vdout0_9ck132 = 0 time = 665
* CHECK dout0_10 vdout0_10ck132 = 0 time = 665
* CHECK dout0_11 vdout0_11ck132 = 3.3 time = 665
* CHECK dout0_12 vdout0_12ck132 = 0 time = 665
* CHECK dout0_13 vdout0_13ck132 = 0 time = 665
* CHECK dout0_14 vdout0_14ck132 = 0 time = 665
* CHECK dout0_15 vdout0_15ck132 = 0 time = 665
* CHECK dout0_16 vdout0_16ck132 = 0 time = 665
* CHECK dout0_17 vdout0_17ck132 = 0 time = 665
* CHECK dout0_18 vdout0_18ck132 = 3.3 time = 665
* CHECK dout0_19 vdout0_19ck132 = 3.3 time = 665
* CHECK dout0_20 vdout0_20ck132 = 0 time = 665
* CHECK dout0_21 vdout0_21ck132 = 3.3 time = 665
* CHECK dout0_22 vdout0_22ck132 = 3.3 time = 665
* CHECK dout0_23 vdout0_23ck132 = 3.3 time = 665
* CHECK dout0_24 vdout0_24ck132 = 3.3 time = 665
* CHECK dout0_25 vdout0_25ck132 = 3.3 time = 665
* CHECK dout0_26 vdout0_26ck132 = 0 time = 665
* CHECK dout0_27 vdout0_27ck132 = 3.3 time = 665
* CHECK dout0_28 vdout0_28ck132 = 3.3 time = 665
* CHECK dout0_29 vdout0_29ck132 = 3.3 time = 665
* CHECK dout0_30 vdout0_30ck132 = 0 time = 665
* CHECK dout0_31 vdout0_31ck132 = 3.3 time = 665
* CHECK dout0_0 vdout0_0ck133 = 3.3 time = 670
* CHECK dout0_1 vdout0_1ck133 = 0 time = 670
* CHECK dout0_2 vdout0_2ck133 = 0 time = 670
* CHECK dout0_3 vdout0_3ck133 = 3.3 time = 670
* CHECK dout0_4 vdout0_4ck133 = 3.3 time = 670
* CHECK dout0_5 vdout0_5ck133 = 3.3 time = 670
* CHECK dout0_6 vdout0_6ck133 = 3.3 time = 670
* CHECK dout0_7 vdout0_7ck133 = 0 time = 670
* CHECK dout0_8 vdout0_8ck133 = 3.3 time = 670
* CHECK dout0_9 vdout0_9ck133 = 0 time = 670
* CHECK dout0_10 vdout0_10ck133 = 3.3 time = 670
* CHECK dout0_11 vdout0_11ck133 = 0 time = 670
* CHECK dout0_12 vdout0_12ck133 = 3.3 time = 670
* CHECK dout0_13 vdout0_13ck133 = 3.3 time = 670
* CHECK dout0_14 vdout0_14ck133 = 3.3 time = 670
* CHECK dout0_15 vdout0_15ck133 = 0 time = 670
* CHECK dout0_16 vdout0_16ck133 = 3.3 time = 670
* CHECK dout0_17 vdout0_17ck133 = 0 time = 670
* CHECK dout0_18 vdout0_18ck133 = 0 time = 670
* CHECK dout0_19 vdout0_19ck133 = 3.3 time = 670
* CHECK dout0_20 vdout0_20ck133 = 0 time = 670
* CHECK dout0_21 vdout0_21ck133 = 3.3 time = 670
* CHECK dout0_22 vdout0_22ck133 = 0 time = 670
* CHECK dout0_23 vdout0_23ck133 = 3.3 time = 670
* CHECK dout0_24 vdout0_24ck133 = 3.3 time = 670
* CHECK dout0_25 vdout0_25ck133 = 0 time = 670
* CHECK dout0_26 vdout0_26ck133 = 3.3 time = 670
* CHECK dout0_27 vdout0_27ck133 = 3.3 time = 670
* CHECK dout0_28 vdout0_28ck133 = 0 time = 670
* CHECK dout0_29 vdout0_29ck133 = 3.3 time = 670
* CHECK dout0_30 vdout0_30ck133 = 3.3 time = 670
* CHECK dout0_31 vdout0_31ck133 = 0 time = 670
* CHECK dout0_0 vdout0_0ck134 = 0 time = 675
* CHECK dout0_1 vdout0_1ck134 = 0 time = 675
* CHECK dout0_2 vdout0_2ck134 = 0 time = 675
* CHECK dout0_3 vdout0_3ck134 = 3.3 time = 675
* CHECK dout0_4 vdout0_4ck134 = 3.3 time = 675
* CHECK dout0_5 vdout0_5ck134 = 0 time = 675
* CHECK dout0_6 vdout0_6ck134 = 0 time = 675
* CHECK dout0_7 vdout0_7ck134 = 0 time = 675
* CHECK dout0_8 vdout0_8ck134 = 0 time = 675
* CHECK dout0_9 vdout0_9ck134 = 0 time = 675
* CHECK dout0_10 vdout0_10ck134 = 0 time = 675
* CHECK dout0_11 vdout0_11ck134 = 3.3 time = 675
* CHECK dout0_12 vdout0_12ck134 = 0 time = 675
* CHECK dout0_13 vdout0_13ck134 = 0 time = 675
* CHECK dout0_14 vdout0_14ck134 = 0 time = 675
* CHECK dout0_15 vdout0_15ck134 = 0 time = 675
* CHECK dout0_16 vdout0_16ck134 = 0 time = 675
* CHECK dout0_17 vdout0_17ck134 = 0 time = 675
* CHECK dout0_18 vdout0_18ck134 = 3.3 time = 675
* CHECK dout0_19 vdout0_19ck134 = 3.3 time = 675
* CHECK dout0_20 vdout0_20ck134 = 0 time = 675
* CHECK dout0_21 vdout0_21ck134 = 3.3 time = 675
* CHECK dout0_22 vdout0_22ck134 = 3.3 time = 675
* CHECK dout0_23 vdout0_23ck134 = 3.3 time = 675
* CHECK dout0_24 vdout0_24ck134 = 3.3 time = 675
* CHECK dout0_25 vdout0_25ck134 = 3.3 time = 675
* CHECK dout0_26 vdout0_26ck134 = 0 time = 675
* CHECK dout0_27 vdout0_27ck134 = 3.3 time = 675
* CHECK dout0_28 vdout0_28ck134 = 3.3 time = 675
* CHECK dout0_29 vdout0_29ck134 = 3.3 time = 675
* CHECK dout0_30 vdout0_30ck134 = 0 time = 675
* CHECK dout0_31 vdout0_31ck134 = 3.3 time = 675
* CHECK dout0_0 vdout0_0ck135 = 0 time = 680
* CHECK dout0_1 vdout0_1ck135 = 0 time = 680
* CHECK dout0_2 vdout0_2ck135 = 0 time = 680
* CHECK dout0_3 vdout0_3ck135 = 3.3 time = 680
* CHECK dout0_4 vdout0_4ck135 = 3.3 time = 680
* CHECK dout0_5 vdout0_5ck135 = 0 time = 680
* CHECK dout0_6 vdout0_6ck135 = 0 time = 680
* CHECK dout0_7 vdout0_7ck135 = 0 time = 680
* CHECK dout0_8 vdout0_8ck135 = 0 time = 680
* CHECK dout0_9 vdout0_9ck135 = 0 time = 680
* CHECK dout0_10 vdout0_10ck135 = 0 time = 680
* CHECK dout0_11 vdout0_11ck135 = 3.3 time = 680
* CHECK dout0_12 vdout0_12ck135 = 0 time = 680
* CHECK dout0_13 vdout0_13ck135 = 0 time = 680
* CHECK dout0_14 vdout0_14ck135 = 0 time = 680
* CHECK dout0_15 vdout0_15ck135 = 0 time = 680
* CHECK dout0_16 vdout0_16ck135 = 0 time = 680
* CHECK dout0_17 vdout0_17ck135 = 0 time = 680
* CHECK dout0_18 vdout0_18ck135 = 3.3 time = 680
* CHECK dout0_19 vdout0_19ck135 = 3.3 time = 680
* CHECK dout0_20 vdout0_20ck135 = 0 time = 680
* CHECK dout0_21 vdout0_21ck135 = 3.3 time = 680
* CHECK dout0_22 vdout0_22ck135 = 3.3 time = 680
* CHECK dout0_23 vdout0_23ck135 = 3.3 time = 680
* CHECK dout0_24 vdout0_24ck135 = 3.3 time = 680
* CHECK dout0_25 vdout0_25ck135 = 3.3 time = 680
* CHECK dout0_26 vdout0_26ck135 = 0 time = 680
* CHECK dout0_27 vdout0_27ck135 = 3.3 time = 680
* CHECK dout0_28 vdout0_28ck135 = 3.3 time = 680
* CHECK dout0_29 vdout0_29ck135 = 3.3 time = 680
* CHECK dout0_30 vdout0_30ck135 = 0 time = 680
* CHECK dout0_31 vdout0_31ck135 = 3.3 time = 680
* CHECK dout0_0 vdout0_0ck136 = 0 time = 685
* CHECK dout0_1 vdout0_1ck136 = 0 time = 685
* CHECK dout0_2 vdout0_2ck136 = 0 time = 685
* CHECK dout0_3 vdout0_3ck136 = 3.3 time = 685
* CHECK dout0_4 vdout0_4ck136 = 3.3 time = 685
* CHECK dout0_5 vdout0_5ck136 = 0 time = 685
* CHECK dout0_6 vdout0_6ck136 = 0 time = 685
* CHECK dout0_7 vdout0_7ck136 = 0 time = 685
* CHECK dout0_8 vdout0_8ck136 = 0 time = 685
* CHECK dout0_9 vdout0_9ck136 = 0 time = 685
* CHECK dout0_10 vdout0_10ck136 = 0 time = 685
* CHECK dout0_11 vdout0_11ck136 = 3.3 time = 685
* CHECK dout0_12 vdout0_12ck136 = 0 time = 685
* CHECK dout0_13 vdout0_13ck136 = 0 time = 685
* CHECK dout0_14 vdout0_14ck136 = 0 time = 685
* CHECK dout0_15 vdout0_15ck136 = 0 time = 685
* CHECK dout0_16 vdout0_16ck136 = 0 time = 685
* CHECK dout0_17 vdout0_17ck136 = 0 time = 685
* CHECK dout0_18 vdout0_18ck136 = 3.3 time = 685
* CHECK dout0_19 vdout0_19ck136 = 3.3 time = 685
* CHECK dout0_20 vdout0_20ck136 = 0 time = 685
* CHECK dout0_21 vdout0_21ck136 = 3.3 time = 685
* CHECK dout0_22 vdout0_22ck136 = 3.3 time = 685
* CHECK dout0_23 vdout0_23ck136 = 3.3 time = 685
* CHECK dout0_24 vdout0_24ck136 = 3.3 time = 685
* CHECK dout0_25 vdout0_25ck136 = 3.3 time = 685
* CHECK dout0_26 vdout0_26ck136 = 0 time = 685
* CHECK dout0_27 vdout0_27ck136 = 3.3 time = 685
* CHECK dout0_28 vdout0_28ck136 = 3.3 time = 685
* CHECK dout0_29 vdout0_29ck136 = 3.3 time = 685
* CHECK dout0_30 vdout0_30ck136 = 0 time = 685
* CHECK dout0_31 vdout0_31ck136 = 3.3 time = 685
* CHECK dout0_0 vdout0_0ck141 = 0 time = 710
* CHECK dout0_1 vdout0_1ck141 = 0 time = 710
* CHECK dout0_2 vdout0_2ck141 = 0 time = 710
* CHECK dout0_3 vdout0_3ck141 = 0 time = 710
* CHECK dout0_4 vdout0_4ck141 = 3.3 time = 710
* CHECK dout0_5 vdout0_5ck141 = 3.3 time = 710
* CHECK dout0_6 vdout0_6ck141 = 3.3 time = 710
* CHECK dout0_7 vdout0_7ck141 = 0 time = 710
* CHECK dout0_8 vdout0_8ck141 = 3.3 time = 710
* CHECK dout0_9 vdout0_9ck141 = 0 time = 710
* CHECK dout0_10 vdout0_10ck141 = 3.3 time = 710
* CHECK dout0_11 vdout0_11ck141 = 3.3 time = 710
* CHECK dout0_12 vdout0_12ck141 = 0 time = 710
* CHECK dout0_13 vdout0_13ck141 = 3.3 time = 710
* CHECK dout0_14 vdout0_14ck141 = 3.3 time = 710
* CHECK dout0_15 vdout0_15ck141 = 0 time = 710
* CHECK dout0_16 vdout0_16ck141 = 3.3 time = 710
* CHECK dout0_17 vdout0_17ck141 = 0 time = 710
* CHECK dout0_18 vdout0_18ck141 = 3.3 time = 710
* CHECK dout0_19 vdout0_19ck141 = 3.3 time = 710
* CHECK dout0_20 vdout0_20ck141 = 0 time = 710
* CHECK dout0_21 vdout0_21ck141 = 0 time = 710
* CHECK dout0_22 vdout0_22ck141 = 3.3 time = 710
* CHECK dout0_23 vdout0_23ck141 = 3.3 time = 710
* CHECK dout0_24 vdout0_24ck141 = 3.3 time = 710
* CHECK dout0_25 vdout0_25ck141 = 0 time = 710
* CHECK dout0_26 vdout0_26ck141 = 3.3 time = 710
* CHECK dout0_27 vdout0_27ck141 = 0 time = 710
* CHECK dout0_28 vdout0_28ck141 = 0 time = 710
* CHECK dout0_29 vdout0_29ck141 = 3.3 time = 710
* CHECK dout0_30 vdout0_30ck141 = 3.3 time = 710
* CHECK dout0_31 vdout0_31ck141 = 0 time = 710
* CHECK dout0_0 vdout0_0ck143 = 0 time = 720
* CHECK dout0_1 vdout0_1ck143 = 3.3 time = 720
* CHECK dout0_2 vdout0_2ck143 = 3.3 time = 720
* CHECK dout0_3 vdout0_3ck143 = 3.3 time = 720
* CHECK dout0_4 vdout0_4ck143 = 3.3 time = 720
* CHECK dout0_5 vdout0_5ck143 = 0 time = 720
* CHECK dout0_6 vdout0_6ck143 = 0 time = 720
* CHECK dout0_7 vdout0_7ck143 = 3.3 time = 720
* CHECK dout0_8 vdout0_8ck143 = 3.3 time = 720
* CHECK dout0_9 vdout0_9ck143 = 3.3 time = 720
* CHECK dout0_10 vdout0_10ck143 = 3.3 time = 720
* CHECK dout0_11 vdout0_11ck143 = 0 time = 720
* CHECK dout0_12 vdout0_12ck143 = 3.3 time = 720
* CHECK dout0_13 vdout0_13ck143 = 3.3 time = 720
* CHECK dout0_14 vdout0_14ck143 = 0 time = 720
* CHECK dout0_15 vdout0_15ck143 = 3.3 time = 720
* CHECK dout0_16 vdout0_16ck143 = 3.3 time = 720
* CHECK dout0_17 vdout0_17ck143 = 0 time = 720
* CHECK dout0_18 vdout0_18ck143 = 3.3 time = 720
* CHECK dout0_19 vdout0_19ck143 = 0 time = 720
* CHECK dout0_20 vdout0_20ck143 = 3.3 time = 720
* CHECK dout0_21 vdout0_21ck143 = 0 time = 720
* CHECK dout0_22 vdout0_22ck143 = 0 time = 720
* CHECK dout0_23 vdout0_23ck143 = 3.3 time = 720
* CHECK dout0_24 vdout0_24ck143 = 0 time = 720
* CHECK dout0_25 vdout0_25ck143 = 3.3 time = 720
* CHECK dout0_26 vdout0_26ck143 = 3.3 time = 720
* CHECK dout0_27 vdout0_27ck143 = 0 time = 720
* CHECK dout0_28 vdout0_28ck143 = 0 time = 720
* CHECK dout0_29 vdout0_29ck143 = 0 time = 720
* CHECK dout0_30 vdout0_30ck143 = 0 time = 720
* CHECK dout0_31 vdout0_31ck143 = 3.3 time = 720
* CHECK dout0_0 vdout0_0ck146 = 3.3 time = 735
* CHECK dout0_1 vdout0_1ck146 = 0 time = 735
* CHECK dout0_2 vdout0_2ck146 = 0 time = 735
* CHECK dout0_3 vdout0_3ck146 = 3.3 time = 735
* CHECK dout0_4 vdout0_4ck146 = 3.3 time = 735
* CHECK dout0_5 vdout0_5ck146 = 3.3 time = 735
* CHECK dout0_6 vdout0_6ck146 = 3.3 time = 735
* CHECK dout0_7 vdout0_7ck146 = 0 time = 735
* CHECK dout0_8 vdout0_8ck146 = 3.3 time = 735
* CHECK dout0_9 vdout0_9ck146 = 0 time = 735
* CHECK dout0_10 vdout0_10ck146 = 3.3 time = 735
* CHECK dout0_11 vdout0_11ck146 = 0 time = 735
* CHECK dout0_12 vdout0_12ck146 = 3.3 time = 735
* CHECK dout0_13 vdout0_13ck146 = 3.3 time = 735
* CHECK dout0_14 vdout0_14ck146 = 3.3 time = 735
* CHECK dout0_15 vdout0_15ck146 = 0 time = 735
* CHECK dout0_16 vdout0_16ck146 = 3.3 time = 735
* CHECK dout0_17 vdout0_17ck146 = 0 time = 735
* CHECK dout0_18 vdout0_18ck146 = 0 time = 735
* CHECK dout0_19 vdout0_19ck146 = 3.3 time = 735
* CHECK dout0_20 vdout0_20ck146 = 0 time = 735
* CHECK dout0_21 vdout0_21ck146 = 3.3 time = 735
* CHECK dout0_22 vdout0_22ck146 = 0 time = 735
* CHECK dout0_23 vdout0_23ck146 = 3.3 time = 735
* CHECK dout0_24 vdout0_24ck146 = 3.3 time = 735
* CHECK dout0_25 vdout0_25ck146 = 0 time = 735
* CHECK dout0_26 vdout0_26ck146 = 3.3 time = 735
* CHECK dout0_27 vdout0_27ck146 = 3.3 time = 735
* CHECK dout0_28 vdout0_28ck146 = 0 time = 735
* CHECK dout0_29 vdout0_29ck146 = 3.3 time = 735
* CHECK dout0_30 vdout0_30ck146 = 3.3 time = 735
* CHECK dout0_31 vdout0_31ck146 = 0 time = 735
* CHECK dout0_0 vdout0_0ck152 = 3.3 time = 765
* CHECK dout0_1 vdout0_1ck152 = 3.3 time = 765
* CHECK dout0_2 vdout0_2ck152 = 0 time = 765
* CHECK dout0_3 vdout0_3ck152 = 3.3 time = 765
* CHECK dout0_4 vdout0_4ck152 = 3.3 time = 765
* CHECK dout0_5 vdout0_5ck152 = 3.3 time = 765
* CHECK dout0_6 vdout0_6ck152 = 0 time = 765
* CHECK dout0_7 vdout0_7ck152 = 3.3 time = 765
* CHECK dout0_8 vdout0_8ck152 = 3.3 time = 765
* CHECK dout0_9 vdout0_9ck152 = 0 time = 765
* CHECK dout0_10 vdout0_10ck152 = 3.3 time = 765
* CHECK dout0_11 vdout0_11ck152 = 3.3 time = 765
* CHECK dout0_12 vdout0_12ck152 = 0 time = 765
* CHECK dout0_13 vdout0_13ck152 = 3.3 time = 765
* CHECK dout0_14 vdout0_14ck152 = 3.3 time = 765
* CHECK dout0_15 vdout0_15ck152 = 0 time = 765
* CHECK dout0_16 vdout0_16ck152 = 0 time = 765
* CHECK dout0_17 vdout0_17ck152 = 3.3 time = 765
* CHECK dout0_18 vdout0_18ck152 = 0 time = 765
* CHECK dout0_19 vdout0_19ck152 = 0 time = 765
* CHECK dout0_20 vdout0_20ck152 = 3.3 time = 765
* CHECK dout0_21 vdout0_21ck152 = 0 time = 765
* CHECK dout0_22 vdout0_22ck152 = 0 time = 765
* CHECK dout0_23 vdout0_23ck152 = 0 time = 765
* CHECK dout0_24 vdout0_24ck152 = 0 time = 765
* CHECK dout0_25 vdout0_25ck152 = 0 time = 765
* CHECK dout0_26 vdout0_26ck152 = 0 time = 765
* CHECK dout0_27 vdout0_27ck152 = 0 time = 765
* CHECK dout0_28 vdout0_28ck152 = 3.3 time = 765
* CHECK dout0_29 vdout0_29ck152 = 3.3 time = 765
* CHECK dout0_30 vdout0_30ck152 = 3.3 time = 765
* CHECK dout0_31 vdout0_31ck152 = 0 time = 765
* CHECK dout0_0 vdout0_0ck153 = 3.3 time = 770
* CHECK dout0_1 vdout0_1ck153 = 3.3 time = 770
* CHECK dout0_2 vdout0_2ck153 = 0 time = 770
* CHECK dout0_3 vdout0_3ck153 = 3.3 time = 770
* CHECK dout0_4 vdout0_4ck153 = 3.3 time = 770
* CHECK dout0_5 vdout0_5ck153 = 3.3 time = 770
* CHECK dout0_6 vdout0_6ck153 = 0 time = 770
* CHECK dout0_7 vdout0_7ck153 = 3.3 time = 770
* CHECK dout0_8 vdout0_8ck153 = 3.3 time = 770
* CHECK dout0_9 vdout0_9ck153 = 0 time = 770
* CHECK dout0_10 vdout0_10ck153 = 3.3 time = 770
* CHECK dout0_11 vdout0_11ck153 = 3.3 time = 770
* CHECK dout0_12 vdout0_12ck153 = 0 time = 770
* CHECK dout0_13 vdout0_13ck153 = 3.3 time = 770
* CHECK dout0_14 vdout0_14ck153 = 3.3 time = 770
* CHECK dout0_15 vdout0_15ck153 = 0 time = 770
* CHECK dout0_16 vdout0_16ck153 = 0 time = 770
* CHECK dout0_17 vdout0_17ck153 = 3.3 time = 770
* CHECK dout0_18 vdout0_18ck153 = 0 time = 770
* CHECK dout0_19 vdout0_19ck153 = 0 time = 770
* CHECK dout0_20 vdout0_20ck153 = 3.3 time = 770
* CHECK dout0_21 vdout0_21ck153 = 0 time = 770
* CHECK dout0_22 vdout0_22ck153 = 0 time = 770
* CHECK dout0_23 vdout0_23ck153 = 0 time = 770
* CHECK dout0_24 vdout0_24ck153 = 0 time = 770
* CHECK dout0_25 vdout0_25ck153 = 0 time = 770
* CHECK dout0_26 vdout0_26ck153 = 0 time = 770
* CHECK dout0_27 vdout0_27ck153 = 0 time = 770
* CHECK dout0_28 vdout0_28ck153 = 3.3 time = 770
* CHECK dout0_29 vdout0_29ck153 = 3.3 time = 770
* CHECK dout0_30 vdout0_30ck153 = 3.3 time = 770
* CHECK dout0_31 vdout0_31ck153 = 0 time = 770
* CHECK dout0_0 vdout0_0ck154 = 3.3 time = 775
* CHECK dout0_1 vdout0_1ck154 = 3.3 time = 775
* CHECK dout0_2 vdout0_2ck154 = 0 time = 775
* CHECK dout0_3 vdout0_3ck154 = 3.3 time = 775
* CHECK dout0_4 vdout0_4ck154 = 3.3 time = 775
* CHECK dout0_5 vdout0_5ck154 = 3.3 time = 775
* CHECK dout0_6 vdout0_6ck154 = 0 time = 775
* CHECK dout0_7 vdout0_7ck154 = 0 time = 775
* CHECK dout0_8 vdout0_8ck154 = 3.3 time = 775
* CHECK dout0_9 vdout0_9ck154 = 3.3 time = 775
* CHECK dout0_10 vdout0_10ck154 = 3.3 time = 775
* CHECK dout0_11 vdout0_11ck154 = 0 time = 775
* CHECK dout0_12 vdout0_12ck154 = 0 time = 775
* CHECK dout0_13 vdout0_13ck154 = 0 time = 775
* CHECK dout0_14 vdout0_14ck154 = 3.3 time = 775
* CHECK dout0_15 vdout0_15ck154 = 0 time = 775
* CHECK dout0_16 vdout0_16ck154 = 3.3 time = 775
* CHECK dout0_17 vdout0_17ck154 = 0 time = 775
* CHECK dout0_18 vdout0_18ck154 = 0 time = 775
* CHECK dout0_19 vdout0_19ck154 = 3.3 time = 775
* CHECK dout0_20 vdout0_20ck154 = 3.3 time = 775
* CHECK dout0_21 vdout0_21ck154 = 3.3 time = 775
* CHECK dout0_22 vdout0_22ck154 = 3.3 time = 775
* CHECK dout0_23 vdout0_23ck154 = 0 time = 775
* CHECK dout0_24 vdout0_24ck154 = 0 time = 775
* CHECK dout0_25 vdout0_25ck154 = 3.3 time = 775
* CHECK dout0_26 vdout0_26ck154 = 0 time = 775
* CHECK dout0_27 vdout0_27ck154 = 3.3 time = 775
* CHECK dout0_28 vdout0_28ck154 = 0 time = 775
* CHECK dout0_29 vdout0_29ck154 = 3.3 time = 775
* CHECK dout0_30 vdout0_30ck154 = 0 time = 775
* CHECK dout0_31 vdout0_31ck154 = 0 time = 775
* CHECK dout0_0 vdout0_0ck156 = 0 time = 785
* CHECK dout0_1 vdout0_1ck156 = 3.3 time = 785
* CHECK dout0_2 vdout0_2ck156 = 3.3 time = 785
* CHECK dout0_3 vdout0_3ck156 = 3.3 time = 785
* CHECK dout0_4 vdout0_4ck156 = 3.3 time = 785
* CHECK dout0_5 vdout0_5ck156 = 3.3 time = 785
* CHECK dout0_6 vdout0_6ck156 = 0 time = 785
* CHECK dout0_7 vdout0_7ck156 = 3.3 time = 785
* CHECK dout0_8 vdout0_8ck156 = 3.3 time = 785
* CHECK dout0_9 vdout0_9ck156 = 3.3 time = 785
* CHECK dout0_10 vdout0_10ck156 = 0 time = 785
* CHECK dout0_11 vdout0_11ck156 = 0 time = 785
* CHECK dout0_12 vdout0_12ck156 = 3.3 time = 785
* CHECK dout0_13 vdout0_13ck156 = 3.3 time = 785
* CHECK dout0_14 vdout0_14ck156 = 0 time = 785
* CHECK dout0_15 vdout0_15ck156 = 3.3 time = 785
* CHECK dout0_16 vdout0_16ck156 = 0 time = 785
* CHECK dout0_17 vdout0_17ck156 = 3.3 time = 785
* CHECK dout0_18 vdout0_18ck156 = 0 time = 785
* CHECK dout0_19 vdout0_19ck156 = 0 time = 785
* CHECK dout0_20 vdout0_20ck156 = 3.3 time = 785
* CHECK dout0_21 vdout0_21ck156 = 0 time = 785
* CHECK dout0_22 vdout0_22ck156 = 0 time = 785
* CHECK dout0_23 vdout0_23ck156 = 3.3 time = 785
* CHECK dout0_24 vdout0_24ck156 = 0 time = 785
* CHECK dout0_25 vdout0_25ck156 = 0 time = 785
* CHECK dout0_26 vdout0_26ck156 = 3.3 time = 785
* CHECK dout0_27 vdout0_27ck156 = 0 time = 785
* CHECK dout0_28 vdout0_28ck156 = 3.3 time = 785
* CHECK dout0_29 vdout0_29ck156 = 0 time = 785
* CHECK dout0_30 vdout0_30ck156 = 3.3 time = 785
* CHECK dout0_31 vdout0_31ck156 = 3.3 time = 785
* CHECK dout0_0 vdout0_0ck158 = 0 time = 795
* CHECK dout0_1 vdout0_1ck158 = 3.3 time = 795
* CHECK dout0_2 vdout0_2ck158 = 3.3 time = 795
* CHECK dout0_3 vdout0_3ck158 = 3.3 time = 795
* CHECK dout0_4 vdout0_4ck158 = 3.3 time = 795
* CHECK dout0_5 vdout0_5ck158 = 3.3 time = 795
* CHECK dout0_6 vdout0_6ck158 = 0 time = 795
* CHECK dout0_7 vdout0_7ck158 = 3.3 time = 795
* CHECK dout0_8 vdout0_8ck158 = 3.3 time = 795
* CHECK dout0_9 vdout0_9ck158 = 3.3 time = 795
* CHECK dout0_10 vdout0_10ck158 = 0 time = 795
* CHECK dout0_11 vdout0_11ck158 = 0 time = 795
* CHECK dout0_12 vdout0_12ck158 = 3.3 time = 795
* CHECK dout0_13 vdout0_13ck158 = 3.3 time = 795
* CHECK dout0_14 vdout0_14ck158 = 0 time = 795
* CHECK dout0_15 vdout0_15ck158 = 3.3 time = 795
* CHECK dout0_16 vdout0_16ck158 = 0 time = 795
* CHECK dout0_17 vdout0_17ck158 = 3.3 time = 795
* CHECK dout0_18 vdout0_18ck158 = 0 time = 795
* CHECK dout0_19 vdout0_19ck158 = 0 time = 795
* CHECK dout0_20 vdout0_20ck158 = 3.3 time = 795
* CHECK dout0_21 vdout0_21ck158 = 0 time = 795
* CHECK dout0_22 vdout0_22ck158 = 0 time = 795
* CHECK dout0_23 vdout0_23ck158 = 3.3 time = 795
* CHECK dout0_24 vdout0_24ck158 = 0 time = 795
* CHECK dout0_25 vdout0_25ck158 = 0 time = 795
* CHECK dout0_26 vdout0_26ck158 = 3.3 time = 795
* CHECK dout0_27 vdout0_27ck158 = 0 time = 795
* CHECK dout0_28 vdout0_28ck158 = 3.3 time = 795
* CHECK dout0_29 vdout0_29ck158 = 0 time = 795
* CHECK dout0_30 vdout0_30ck158 = 3.3 time = 795
* CHECK dout0_31 vdout0_31ck158 = 3.3 time = 795
* CHECK dout0_0 vdout0_0ck160 = 0 time = 805
* CHECK dout0_1 vdout0_1ck160 = 3.3 time = 805
* CHECK dout0_2 vdout0_2ck160 = 3.3 time = 805
* CHECK dout0_3 vdout0_3ck160 = 3.3 time = 805
* CHECK dout0_4 vdout0_4ck160 = 3.3 time = 805
* CHECK dout0_5 vdout0_5ck160 = 3.3 time = 805
* CHECK dout0_6 vdout0_6ck160 = 0 time = 805
* CHECK dout0_7 vdout0_7ck160 = 3.3 time = 805
* CHECK dout0_8 vdout0_8ck160 = 3.3 time = 805
* CHECK dout0_9 vdout0_9ck160 = 3.3 time = 805
* CHECK dout0_10 vdout0_10ck160 = 0 time = 805
* CHECK dout0_11 vdout0_11ck160 = 0 time = 805
* CHECK dout0_12 vdout0_12ck160 = 3.3 time = 805
* CHECK dout0_13 vdout0_13ck160 = 3.3 time = 805
* CHECK dout0_14 vdout0_14ck160 = 0 time = 805
* CHECK dout0_15 vdout0_15ck160 = 3.3 time = 805
* CHECK dout0_16 vdout0_16ck160 = 0 time = 805
* CHECK dout0_17 vdout0_17ck160 = 3.3 time = 805
* CHECK dout0_18 vdout0_18ck160 = 0 time = 805
* CHECK dout0_19 vdout0_19ck160 = 0 time = 805
* CHECK dout0_20 vdout0_20ck160 = 3.3 time = 805
* CHECK dout0_21 vdout0_21ck160 = 0 time = 805
* CHECK dout0_22 vdout0_22ck160 = 0 time = 805
* CHECK dout0_23 vdout0_23ck160 = 3.3 time = 805
* CHECK dout0_24 vdout0_24ck160 = 0 time = 805
* CHECK dout0_25 vdout0_25ck160 = 0 time = 805
* CHECK dout0_26 vdout0_26ck160 = 3.3 time = 805
* CHECK dout0_27 vdout0_27ck160 = 0 time = 805
* CHECK dout0_28 vdout0_28ck160 = 3.3 time = 805
* CHECK dout0_29 vdout0_29ck160 = 0 time = 805
* CHECK dout0_30 vdout0_30ck160 = 3.3 time = 805
* CHECK dout0_31 vdout0_31ck160 = 3.3 time = 805
* CHECK dout0_0 vdout0_0ck165 = 3.3 time = 830
* CHECK dout0_1 vdout0_1ck165 = 3.3 time = 830
* CHECK dout0_2 vdout0_2ck165 = 0 time = 830
* CHECK dout0_3 vdout0_3ck165 = 3.3 time = 830
* CHECK dout0_4 vdout0_4ck165 = 3.3 time = 830
* CHECK dout0_5 vdout0_5ck165 = 3.3 time = 830
* CHECK dout0_6 vdout0_6ck165 = 0 time = 830
* CHECK dout0_7 vdout0_7ck165 = 3.3 time = 830
* CHECK dout0_8 vdout0_8ck165 = 3.3 time = 830
* CHECK dout0_9 vdout0_9ck165 = 0 time = 830
* CHECK dout0_10 vdout0_10ck165 = 3.3 time = 830
* CHECK dout0_11 vdout0_11ck165 = 3.3 time = 830
* CHECK dout0_12 vdout0_12ck165 = 0 time = 830
* CHECK dout0_13 vdout0_13ck165 = 3.3 time = 830
* CHECK dout0_14 vdout0_14ck165 = 3.3 time = 830
* CHECK dout0_15 vdout0_15ck165 = 0 time = 830
* CHECK dout0_16 vdout0_16ck165 = 0 time = 830
* CHECK dout0_17 vdout0_17ck165 = 3.3 time = 830
* CHECK dout0_18 vdout0_18ck165 = 0 time = 830
* CHECK dout0_19 vdout0_19ck165 = 0 time = 830
* CHECK dout0_20 vdout0_20ck165 = 3.3 time = 830
* CHECK dout0_21 vdout0_21ck165 = 0 time = 830
* CHECK dout0_22 vdout0_22ck165 = 0 time = 830
* CHECK dout0_23 vdout0_23ck165 = 0 time = 830
* CHECK dout0_24 vdout0_24ck165 = 0 time = 830
* CHECK dout0_25 vdout0_25ck165 = 0 time = 830
* CHECK dout0_26 vdout0_26ck165 = 0 time = 830
* CHECK dout0_27 vdout0_27ck165 = 0 time = 830
* CHECK dout0_28 vdout0_28ck165 = 3.3 time = 830
* CHECK dout0_29 vdout0_29ck165 = 3.3 time = 830
* CHECK dout0_30 vdout0_30ck165 = 3.3 time = 830
* CHECK dout0_31 vdout0_31ck165 = 0 time = 830
* CHECK dout0_0 vdout0_0ck168 = 3.3 time = 845
* CHECK dout0_1 vdout0_1ck168 = 0 time = 845
* CHECK dout0_2 vdout0_2ck168 = 0 time = 845
* CHECK dout0_3 vdout0_3ck168 = 0 time = 845
* CHECK dout0_4 vdout0_4ck168 = 0 time = 845
* CHECK dout0_5 vdout0_5ck168 = 0 time = 845
* CHECK dout0_6 vdout0_6ck168 = 0 time = 845
* CHECK dout0_7 vdout0_7ck168 = 0 time = 845
* CHECK dout0_8 vdout0_8ck168 = 0 time = 845
* CHECK dout0_9 vdout0_9ck168 = 3.3 time = 845
* CHECK dout0_10 vdout0_10ck168 = 3.3 time = 845
* CHECK dout0_11 vdout0_11ck168 = 0 time = 845
* CHECK dout0_12 vdout0_12ck168 = 3.3 time = 845
* CHECK dout0_13 vdout0_13ck168 = 3.3 time = 845
* CHECK dout0_14 vdout0_14ck168 = 0 time = 845
* CHECK dout0_15 vdout0_15ck168 = 3.3 time = 845
* CHECK dout0_16 vdout0_16ck168 = 0 time = 845
* CHECK dout0_17 vdout0_17ck168 = 0 time = 845
* CHECK dout0_18 vdout0_18ck168 = 0 time = 845
* CHECK dout0_19 vdout0_19ck168 = 3.3 time = 845
* CHECK dout0_20 vdout0_20ck168 = 3.3 time = 845
* CHECK dout0_21 vdout0_21ck168 = 0 time = 845
* CHECK dout0_22 vdout0_22ck168 = 3.3 time = 845
* CHECK dout0_23 vdout0_23ck168 = 0 time = 845
* CHECK dout0_24 vdout0_24ck168 = 3.3 time = 845
* CHECK dout0_25 vdout0_25ck168 = 0 time = 845
* CHECK dout0_26 vdout0_26ck168 = 3.3 time = 845
* CHECK dout0_27 vdout0_27ck168 = 0 time = 845
* CHECK dout0_28 vdout0_28ck168 = 0 time = 845
* CHECK dout0_29 vdout0_29ck168 = 3.3 time = 845
* CHECK dout0_30 vdout0_30ck168 = 3.3 time = 845
* CHECK dout0_31 vdout0_31ck168 = 0 time = 845
* CHECK dout0_0 vdout0_0ck169 = 3.3 time = 850
* CHECK dout0_1 vdout0_1ck169 = 0 time = 850
* CHECK dout0_2 vdout0_2ck169 = 0 time = 850
* CHECK dout0_3 vdout0_3ck169 = 0 time = 850
* CHECK dout0_4 vdout0_4ck169 = 0 time = 850
* CHECK dout0_5 vdout0_5ck169 = 0 time = 850
* CHECK dout0_6 vdout0_6ck169 = 0 time = 850
* CHECK dout0_7 vdout0_7ck169 = 0 time = 850
* CHECK dout0_8 vdout0_8ck169 = 0 time = 850
* CHECK dout0_9 vdout0_9ck169 = 3.3 time = 850
* CHECK dout0_10 vdout0_10ck169 = 3.3 time = 850
* CHECK dout0_11 vdout0_11ck169 = 0 time = 850
* CHECK dout0_12 vdout0_12ck169 = 3.3 time = 850
* CHECK dout0_13 vdout0_13ck169 = 3.3 time = 850
* CHECK dout0_14 vdout0_14ck169 = 0 time = 850
* CHECK dout0_15 vdout0_15ck169 = 3.3 time = 850
* CHECK dout0_16 vdout0_16ck169 = 0 time = 850
* CHECK dout0_17 vdout0_17ck169 = 0 time = 850
* CHECK dout0_18 vdout0_18ck169 = 0 time = 850
* CHECK dout0_19 vdout0_19ck169 = 3.3 time = 850
* CHECK dout0_20 vdout0_20ck169 = 3.3 time = 850
* CHECK dout0_21 vdout0_21ck169 = 0 time = 850
* CHECK dout0_22 vdout0_22ck169 = 3.3 time = 850
* CHECK dout0_23 vdout0_23ck169 = 0 time = 850
* CHECK dout0_24 vdout0_24ck169 = 3.3 time = 850
* CHECK dout0_25 vdout0_25ck169 = 0 time = 850
* CHECK dout0_26 vdout0_26ck169 = 3.3 time = 850
* CHECK dout0_27 vdout0_27ck169 = 0 time = 850
* CHECK dout0_28 vdout0_28ck169 = 0 time = 850
* CHECK dout0_29 vdout0_29ck169 = 3.3 time = 850
* CHECK dout0_30 vdout0_30ck169 = 3.3 time = 850
* CHECK dout0_31 vdout0_31ck169 = 0 time = 850
* CHECK dout0_0 vdout0_0ck170 = 3.3 time = 855
* CHECK dout0_1 vdout0_1ck170 = 0 time = 855
* CHECK dout0_2 vdout0_2ck170 = 0 time = 855
* CHECK dout0_3 vdout0_3ck170 = 0 time = 855
* CHECK dout0_4 vdout0_4ck170 = 0 time = 855
* CHECK dout0_5 vdout0_5ck170 = 0 time = 855
* CHECK dout0_6 vdout0_6ck170 = 3.3 time = 855
* CHECK dout0_7 vdout0_7ck170 = 0 time = 855
* CHECK dout0_8 vdout0_8ck170 = 3.3 time = 855
* CHECK dout0_9 vdout0_9ck170 = 0 time = 855
* CHECK dout0_10 vdout0_10ck170 = 3.3 time = 855
* CHECK dout0_11 vdout0_11ck170 = 3.3 time = 855
* CHECK dout0_12 vdout0_12ck170 = 0 time = 855
* CHECK dout0_13 vdout0_13ck170 = 0 time = 855
* CHECK dout0_14 vdout0_14ck170 = 3.3 time = 855
* CHECK dout0_15 vdout0_15ck170 = 3.3 time = 855
* CHECK dout0_16 vdout0_16ck170 = 0 time = 855
* CHECK dout0_17 vdout0_17ck170 = 0 time = 855
* CHECK dout0_18 vdout0_18ck170 = 3.3 time = 855
* CHECK dout0_19 vdout0_19ck170 = 3.3 time = 855
* CHECK dout0_20 vdout0_20ck170 = 0 time = 855
* CHECK dout0_21 vdout0_21ck170 = 0 time = 855
* CHECK dout0_22 vdout0_22ck170 = 0 time = 855
* CHECK dout0_23 vdout0_23ck170 = 3.3 time = 855
* CHECK dout0_24 vdout0_24ck170 = 3.3 time = 855
* CHECK dout0_25 vdout0_25ck170 = 3.3 time = 855
* CHECK dout0_26 vdout0_26ck170 = 0 time = 855
* CHECK dout0_27 vdout0_27ck170 = 0 time = 855
* CHECK dout0_28 vdout0_28ck170 = 3.3 time = 855
* CHECK dout0_29 vdout0_29ck170 = 3.3 time = 855
* CHECK dout0_30 vdout0_30ck170 = 0 time = 855
* CHECK dout0_31 vdout0_31ck170 = 3.3 time = 855
* CHECK dout0_0 vdout0_0ck172 = 3.3 time = 865
* CHECK dout0_1 vdout0_1ck172 = 0 time = 865
* CHECK dout0_2 vdout0_2ck172 = 0 time = 865
* CHECK dout0_3 vdout0_3ck172 = 0 time = 865
* CHECK dout0_4 vdout0_4ck172 = 0 time = 865
* CHECK dout0_5 vdout0_5ck172 = 0 time = 865
* CHECK dout0_6 vdout0_6ck172 = 3.3 time = 865
* CHECK dout0_7 vdout0_7ck172 = 0 time = 865
* CHECK dout0_8 vdout0_8ck172 = 3.3 time = 865
* CHECK dout0_9 vdout0_9ck172 = 0 time = 865
* CHECK dout0_10 vdout0_10ck172 = 3.3 time = 865
* CHECK dout0_11 vdout0_11ck172 = 3.3 time = 865
* CHECK dout0_12 vdout0_12ck172 = 0 time = 865
* CHECK dout0_13 vdout0_13ck172 = 0 time = 865
* CHECK dout0_14 vdout0_14ck172 = 3.3 time = 865
* CHECK dout0_15 vdout0_15ck172 = 3.3 time = 865
* CHECK dout0_16 vdout0_16ck172 = 0 time = 865
* CHECK dout0_17 vdout0_17ck172 = 0 time = 865
* CHECK dout0_18 vdout0_18ck172 = 3.3 time = 865
* CHECK dout0_19 vdout0_19ck172 = 3.3 time = 865
* CHECK dout0_20 vdout0_20ck172 = 0 time = 865
* CHECK dout0_21 vdout0_21ck172 = 0 time = 865
* CHECK dout0_22 vdout0_22ck172 = 0 time = 865
* CHECK dout0_23 vdout0_23ck172 = 3.3 time = 865
* CHECK dout0_24 vdout0_24ck172 = 3.3 time = 865
* CHECK dout0_25 vdout0_25ck172 = 3.3 time = 865
* CHECK dout0_26 vdout0_26ck172 = 0 time = 865
* CHECK dout0_27 vdout0_27ck172 = 0 time = 865
* CHECK dout0_28 vdout0_28ck172 = 3.3 time = 865
* CHECK dout0_29 vdout0_29ck172 = 3.3 time = 865
* CHECK dout0_30 vdout0_30ck172 = 0 time = 865
* CHECK dout0_31 vdout0_31ck172 = 3.3 time = 865
* CHECK dout0_0 vdout0_0ck174 = 3.3 time = 875
* CHECK dout0_1 vdout0_1ck174 = 0 time = 875
* CHECK dout0_2 vdout0_2ck174 = 0 time = 875
* CHECK dout0_3 vdout0_3ck174 = 0 time = 875
* CHECK dout0_4 vdout0_4ck174 = 0 time = 875
* CHECK dout0_5 vdout0_5ck174 = 0 time = 875
* CHECK dout0_6 vdout0_6ck174 = 0 time = 875
* CHECK dout0_7 vdout0_7ck174 = 0 time = 875
* CHECK dout0_8 vdout0_8ck174 = 0 time = 875
* CHECK dout0_9 vdout0_9ck174 = 3.3 time = 875
* CHECK dout0_10 vdout0_10ck174 = 3.3 time = 875
* CHECK dout0_11 vdout0_11ck174 = 0 time = 875
* CHECK dout0_12 vdout0_12ck174 = 3.3 time = 875
* CHECK dout0_13 vdout0_13ck174 = 3.3 time = 875
* CHECK dout0_14 vdout0_14ck174 = 0 time = 875
* CHECK dout0_15 vdout0_15ck174 = 3.3 time = 875
* CHECK dout0_16 vdout0_16ck174 = 0 time = 875
* CHECK dout0_17 vdout0_17ck174 = 0 time = 875
* CHECK dout0_18 vdout0_18ck174 = 0 time = 875
* CHECK dout0_19 vdout0_19ck174 = 3.3 time = 875
* CHECK dout0_20 vdout0_20ck174 = 3.3 time = 875
* CHECK dout0_21 vdout0_21ck174 = 0 time = 875
* CHECK dout0_22 vdout0_22ck174 = 3.3 time = 875
* CHECK dout0_23 vdout0_23ck174 = 0 time = 875
* CHECK dout0_24 vdout0_24ck174 = 3.3 time = 875
* CHECK dout0_25 vdout0_25ck174 = 0 time = 875
* CHECK dout0_26 vdout0_26ck174 = 3.3 time = 875
* CHECK dout0_27 vdout0_27ck174 = 0 time = 875
* CHECK dout0_28 vdout0_28ck174 = 0 time = 875
* CHECK dout0_29 vdout0_29ck174 = 3.3 time = 875
* CHECK dout0_30 vdout0_30ck174 = 3.3 time = 875
* CHECK dout0_31 vdout0_31ck174 = 0 time = 875
* CHECK dout0_0 vdout0_0ck176 = 3.3 time = 885
* CHECK dout0_1 vdout0_1ck176 = 0 time = 885
* CHECK dout0_2 vdout0_2ck176 = 0 time = 885
* CHECK dout0_3 vdout0_3ck176 = 0 time = 885
* CHECK dout0_4 vdout0_4ck176 = 0 time = 885
* CHECK dout0_5 vdout0_5ck176 = 0 time = 885
* CHECK dout0_6 vdout0_6ck176 = 0 time = 885
* CHECK dout0_7 vdout0_7ck176 = 0 time = 885
* CHECK dout0_8 vdout0_8ck176 = 0 time = 885
* CHECK dout0_9 vdout0_9ck176 = 3.3 time = 885
* CHECK dout0_10 vdout0_10ck176 = 3.3 time = 885
* CHECK dout0_11 vdout0_11ck176 = 0 time = 885
* CHECK dout0_12 vdout0_12ck176 = 3.3 time = 885
* CHECK dout0_13 vdout0_13ck176 = 3.3 time = 885
* CHECK dout0_14 vdout0_14ck176 = 0 time = 885
* CHECK dout0_15 vdout0_15ck176 = 3.3 time = 885
* CHECK dout0_16 vdout0_16ck176 = 0 time = 885
* CHECK dout0_17 vdout0_17ck176 = 0 time = 885
* CHECK dout0_18 vdout0_18ck176 = 0 time = 885
* CHECK dout0_19 vdout0_19ck176 = 3.3 time = 885
* CHECK dout0_20 vdout0_20ck176 = 3.3 time = 885
* CHECK dout0_21 vdout0_21ck176 = 0 time = 885
* CHECK dout0_22 vdout0_22ck176 = 3.3 time = 885
* CHECK dout0_23 vdout0_23ck176 = 0 time = 885
* CHECK dout0_24 vdout0_24ck176 = 3.3 time = 885
* CHECK dout0_25 vdout0_25ck176 = 0 time = 885
* CHECK dout0_26 vdout0_26ck176 = 3.3 time = 885
* CHECK dout0_27 vdout0_27ck176 = 0 time = 885
* CHECK dout0_28 vdout0_28ck176 = 0 time = 885
* CHECK dout0_29 vdout0_29ck176 = 3.3 time = 885
* CHECK dout0_30 vdout0_30ck176 = 3.3 time = 885
* CHECK dout0_31 vdout0_31ck176 = 0 time = 885
* CHECK dout0_0 vdout0_0ck177 = 0 time = 890
* CHECK dout0_1 vdout0_1ck177 = 3.3 time = 890
* CHECK dout0_2 vdout0_2ck177 = 3.3 time = 890
* CHECK dout0_3 vdout0_3ck177 = 3.3 time = 890
* CHECK dout0_4 vdout0_4ck177 = 0 time = 890
* CHECK dout0_5 vdout0_5ck177 = 3.3 time = 890
* CHECK dout0_6 vdout0_6ck177 = 0 time = 890
* CHECK dout0_7 vdout0_7ck177 = 3.3 time = 890
* CHECK dout0_8 vdout0_8ck177 = 0 time = 890
* CHECK dout0_9 vdout0_9ck177 = 0 time = 890
* CHECK dout0_10 vdout0_10ck177 = 3.3 time = 890
* CHECK dout0_11 vdout0_11ck177 = 3.3 time = 890
* CHECK dout0_12 vdout0_12ck177 = 0 time = 890
* CHECK dout0_13 vdout0_13ck177 = 0 time = 890
* CHECK dout0_14 vdout0_14ck177 = 0 time = 890
* CHECK dout0_15 vdout0_15ck177 = 3.3 time = 890
* CHECK dout0_16 vdout0_16ck177 = 0 time = 890
* CHECK dout0_17 vdout0_17ck177 = 0 time = 890
* CHECK dout0_18 vdout0_18ck177 = 0 time = 890
* CHECK dout0_19 vdout0_19ck177 = 0 time = 890
* CHECK dout0_20 vdout0_20ck177 = 0 time = 890
* CHECK dout0_21 vdout0_21ck177 = 0 time = 890
* CHECK dout0_22 vdout0_22ck177 = 0 time = 890
* CHECK dout0_23 vdout0_23ck177 = 3.3 time = 890
* CHECK dout0_24 vdout0_24ck177 = 0 time = 890
* CHECK dout0_25 vdout0_25ck177 = 0 time = 890
* CHECK dout0_26 vdout0_26ck177 = 3.3 time = 890
* CHECK dout0_27 vdout0_27ck177 = 0 time = 890
* CHECK dout0_28 vdout0_28ck177 = 3.3 time = 890
* CHECK dout0_29 vdout0_29ck177 = 3.3 time = 890
* CHECK dout0_30 vdout0_30ck177 = 3.3 time = 890
* CHECK dout0_31 vdout0_31ck177 = 0 time = 890
* CHECK dout0_0 vdout0_0ck180 = 3.3 time = 905
* CHECK dout0_1 vdout0_1ck180 = 3.3 time = 905
* CHECK dout0_2 vdout0_2ck180 = 3.3 time = 905
* CHECK dout0_3 vdout0_3ck180 = 0 time = 905
* CHECK dout0_4 vdout0_4ck180 = 0 time = 905
* CHECK dout0_5 vdout0_5ck180 = 0 time = 905
* CHECK dout0_6 vdout0_6ck180 = 0 time = 905
* CHECK dout0_7 vdout0_7ck180 = 3.3 time = 905
* CHECK dout0_8 vdout0_8ck180 = 3.3 time = 905
* CHECK dout0_9 vdout0_9ck180 = 0 time = 905
* CHECK dout0_10 vdout0_10ck180 = 3.3 time = 905
* CHECK dout0_11 vdout0_11ck180 = 3.3 time = 905
* CHECK dout0_12 vdout0_12ck180 = 0 time = 905
* CHECK dout0_13 vdout0_13ck180 = 3.3 time = 905
* CHECK dout0_14 vdout0_14ck180 = 3.3 time = 905
* CHECK dout0_15 vdout0_15ck180 = 0 time = 905
* CHECK dout0_16 vdout0_16ck180 = 3.3 time = 905
* CHECK dout0_17 vdout0_17ck180 = 0 time = 905
* CHECK dout0_18 vdout0_18ck180 = 0 time = 905
* CHECK dout0_19 vdout0_19ck180 = 0 time = 905
* CHECK dout0_20 vdout0_20ck180 = 0 time = 905
* CHECK dout0_21 vdout0_21ck180 = 0 time = 905
* CHECK dout0_22 vdout0_22ck180 = 0 time = 905
* CHECK dout0_23 vdout0_23ck180 = 3.3 time = 905
* CHECK dout0_24 vdout0_24ck180 = 0 time = 905
* CHECK dout0_25 vdout0_25ck180 = 0 time = 905
* CHECK dout0_26 vdout0_26ck180 = 3.3 time = 905
* CHECK dout0_27 vdout0_27ck180 = 3.3 time = 905
* CHECK dout0_28 vdout0_28ck180 = 3.3 time = 905
* CHECK dout0_29 vdout0_29ck180 = 0 time = 905
* CHECK dout0_30 vdout0_30ck180 = 0 time = 905
* CHECK dout0_31 vdout0_31ck180 = 0 time = 905
* CHECK dout0_0 vdout0_0ck181 = 0 time = 910
* CHECK dout0_1 vdout0_1ck181 = 0 time = 910
* CHECK dout0_2 vdout0_2ck181 = 3.3 time = 910
* CHECK dout0_3 vdout0_3ck181 = 0 time = 910
* CHECK dout0_4 vdout0_4ck181 = 0 time = 910
* CHECK dout0_5 vdout0_5ck181 = 0 time = 910
* CHECK dout0_6 vdout0_6ck181 = 0 time = 910
* CHECK dout0_7 vdout0_7ck181 = 0 time = 910
* CHECK dout0_8 vdout0_8ck181 = 0 time = 910
* CHECK dout0_9 vdout0_9ck181 = 0 time = 910
* CHECK dout0_10 vdout0_10ck181 = 3.3 time = 910
* CHECK dout0_11 vdout0_11ck181 = 3.3 time = 910
* CHECK dout0_12 vdout0_12ck181 = 0 time = 910
* CHECK dout0_13 vdout0_13ck181 = 3.3 time = 910
* CHECK dout0_14 vdout0_14ck181 = 3.3 time = 910
* CHECK dout0_15 vdout0_15ck181 = 3.3 time = 910
* CHECK dout0_16 vdout0_16ck181 = 0 time = 910
* CHECK dout0_17 vdout0_17ck181 = 0 time = 910
* CHECK dout0_18 vdout0_18ck181 = 0 time = 910
* CHECK dout0_19 vdout0_19ck181 = 0 time = 910
* CHECK dout0_20 vdout0_20ck181 = 3.3 time = 910
* CHECK dout0_21 vdout0_21ck181 = 3.3 time = 910
* CHECK dout0_22 vdout0_22ck181 = 0 time = 910
* CHECK dout0_23 vdout0_23ck181 = 3.3 time = 910
* CHECK dout0_24 vdout0_24ck181 = 3.3 time = 910
* CHECK dout0_25 vdout0_25ck181 = 0 time = 910
* CHECK dout0_26 vdout0_26ck181 = 3.3 time = 910
* CHECK dout0_27 vdout0_27ck181 = 0 time = 910
* CHECK dout0_28 vdout0_28ck181 = 3.3 time = 910
* CHECK dout0_29 vdout0_29ck181 = 0 time = 910
* CHECK dout0_30 vdout0_30ck181 = 0 time = 910
* CHECK dout0_31 vdout0_31ck181 = 0 time = 910
* CHECK dout0_0 vdout0_0ck182 = 0 time = 915
* CHECK dout0_1 vdout0_1ck182 = 0 time = 915
* CHECK dout0_2 vdout0_2ck182 = 3.3 time = 915
* CHECK dout0_3 vdout0_3ck182 = 0 time = 915
* CHECK dout0_4 vdout0_4ck182 = 0 time = 915
* CHECK dout0_5 vdout0_5ck182 = 0 time = 915
* CHECK dout0_6 vdout0_6ck182 = 0 time = 915
* CHECK dout0_7 vdout0_7ck182 = 0 time = 915
* CHECK dout0_8 vdout0_8ck182 = 0 time = 915
* CHECK dout0_9 vdout0_9ck182 = 0 time = 915
* CHECK dout0_10 vdout0_10ck182 = 3.3 time = 915
* CHECK dout0_11 vdout0_11ck182 = 3.3 time = 915
* CHECK dout0_12 vdout0_12ck182 = 0 time = 915
* CHECK dout0_13 vdout0_13ck182 = 3.3 time = 915
* CHECK dout0_14 vdout0_14ck182 = 3.3 time = 915
* CHECK dout0_15 vdout0_15ck182 = 3.3 time = 915
* CHECK dout0_16 vdout0_16ck182 = 0 time = 915
* CHECK dout0_17 vdout0_17ck182 = 0 time = 915
* CHECK dout0_18 vdout0_18ck182 = 0 time = 915
* CHECK dout0_19 vdout0_19ck182 = 0 time = 915
* CHECK dout0_20 vdout0_20ck182 = 3.3 time = 915
* CHECK dout0_21 vdout0_21ck182 = 3.3 time = 915
* CHECK dout0_22 vdout0_22ck182 = 0 time = 915
* CHECK dout0_23 vdout0_23ck182 = 3.3 time = 915
* CHECK dout0_24 vdout0_24ck182 = 3.3 time = 915
* CHECK dout0_25 vdout0_25ck182 = 0 time = 915
* CHECK dout0_26 vdout0_26ck182 = 3.3 time = 915
* CHECK dout0_27 vdout0_27ck182 = 0 time = 915
* CHECK dout0_28 vdout0_28ck182 = 3.3 time = 915
* CHECK dout0_29 vdout0_29ck182 = 0 time = 915
* CHECK dout0_30 vdout0_30ck182 = 0 time = 915
* CHECK dout0_31 vdout0_31ck182 = 0 time = 915
* CHECK dout0_0 vdout0_0ck184 = 0 time = 925
* CHECK dout0_1 vdout0_1ck184 = 0 time = 925
* CHECK dout0_2 vdout0_2ck184 = 3.3 time = 925
* CHECK dout0_3 vdout0_3ck184 = 0 time = 925
* CHECK dout0_4 vdout0_4ck184 = 0 time = 925
* CHECK dout0_5 vdout0_5ck184 = 0 time = 925
* CHECK dout0_6 vdout0_6ck184 = 0 time = 925
* CHECK dout0_7 vdout0_7ck184 = 0 time = 925
* CHECK dout0_8 vdout0_8ck184 = 0 time = 925
* CHECK dout0_9 vdout0_9ck184 = 0 time = 925
* CHECK dout0_10 vdout0_10ck184 = 3.3 time = 925
* CHECK dout0_11 vdout0_11ck184 = 3.3 time = 925
* CHECK dout0_12 vdout0_12ck184 = 0 time = 925
* CHECK dout0_13 vdout0_13ck184 = 3.3 time = 925
* CHECK dout0_14 vdout0_14ck184 = 3.3 time = 925
* CHECK dout0_15 vdout0_15ck184 = 3.3 time = 925
* CHECK dout0_16 vdout0_16ck184 = 0 time = 925
* CHECK dout0_17 vdout0_17ck184 = 0 time = 925
* CHECK dout0_18 vdout0_18ck184 = 0 time = 925
* CHECK dout0_19 vdout0_19ck184 = 0 time = 925
* CHECK dout0_20 vdout0_20ck184 = 3.3 time = 925
* CHECK dout0_21 vdout0_21ck184 = 3.3 time = 925
* CHECK dout0_22 vdout0_22ck184 = 0 time = 925
* CHECK dout0_23 vdout0_23ck184 = 3.3 time = 925
* CHECK dout0_24 vdout0_24ck184 = 3.3 time = 925
* CHECK dout0_25 vdout0_25ck184 = 0 time = 925
* CHECK dout0_26 vdout0_26ck184 = 3.3 time = 925
* CHECK dout0_27 vdout0_27ck184 = 0 time = 925
* CHECK dout0_28 vdout0_28ck184 = 3.3 time = 925
* CHECK dout0_29 vdout0_29ck184 = 0 time = 925
* CHECK dout0_30 vdout0_30ck184 = 0 time = 925
* CHECK dout0_31 vdout0_31ck184 = 0 time = 925
* CHECK dout0_0 vdout0_0ck185 = 3.3 time = 930
* CHECK dout0_1 vdout0_1ck185 = 3.3 time = 930
* CHECK dout0_2 vdout0_2ck185 = 3.3 time = 930
* CHECK dout0_3 vdout0_3ck185 = 0 time = 930
* CHECK dout0_4 vdout0_4ck185 = 0 time = 930
* CHECK dout0_5 vdout0_5ck185 = 0 time = 930
* CHECK dout0_6 vdout0_6ck185 = 0 time = 930
* CHECK dout0_7 vdout0_7ck185 = 3.3 time = 930
* CHECK dout0_8 vdout0_8ck185 = 3.3 time = 930
* CHECK dout0_9 vdout0_9ck185 = 0 time = 930
* CHECK dout0_10 vdout0_10ck185 = 3.3 time = 930
* CHECK dout0_11 vdout0_11ck185 = 3.3 time = 930
* CHECK dout0_12 vdout0_12ck185 = 0 time = 930
* CHECK dout0_13 vdout0_13ck185 = 3.3 time = 930
* CHECK dout0_14 vdout0_14ck185 = 3.3 time = 930
* CHECK dout0_15 vdout0_15ck185 = 0 time = 930
* CHECK dout0_16 vdout0_16ck185 = 3.3 time = 930
* CHECK dout0_17 vdout0_17ck185 = 0 time = 930
* CHECK dout0_18 vdout0_18ck185 = 0 time = 930
* CHECK dout0_19 vdout0_19ck185 = 0 time = 930
* CHECK dout0_20 vdout0_20ck185 = 0 time = 930
* CHECK dout0_21 vdout0_21ck185 = 0 time = 930
* CHECK dout0_22 vdout0_22ck185 = 0 time = 930
* CHECK dout0_23 vdout0_23ck185 = 3.3 time = 930
* CHECK dout0_24 vdout0_24ck185 = 0 time = 930
* CHECK dout0_25 vdout0_25ck185 = 0 time = 930
* CHECK dout0_26 vdout0_26ck185 = 3.3 time = 930
* CHECK dout0_27 vdout0_27ck185 = 3.3 time = 930
* CHECK dout0_28 vdout0_28ck185 = 3.3 time = 930
* CHECK dout0_29 vdout0_29ck185 = 0 time = 930
* CHECK dout0_30 vdout0_30ck185 = 0 time = 930
* CHECK dout0_31 vdout0_31ck185 = 0 time = 930
* CHECK dout0_0 vdout0_0ck187 = 0 time = 940
* CHECK dout0_1 vdout0_1ck187 = 0 time = 940
* CHECK dout0_2 vdout0_2ck187 = 3.3 time = 940
* CHECK dout0_3 vdout0_3ck187 = 0 time = 940
* CHECK dout0_4 vdout0_4ck187 = 0 time = 940
* CHECK dout0_5 vdout0_5ck187 = 0 time = 940
* CHECK dout0_6 vdout0_6ck187 = 0 time = 940
* CHECK dout0_7 vdout0_7ck187 = 0 time = 940
* CHECK dout0_8 vdout0_8ck187 = 0 time = 940
* CHECK dout0_9 vdout0_9ck187 = 0 time = 940
* CHECK dout0_10 vdout0_10ck187 = 3.3 time = 940
* CHECK dout0_11 vdout0_11ck187 = 3.3 time = 940
* CHECK dout0_12 vdout0_12ck187 = 0 time = 940
* CHECK dout0_13 vdout0_13ck187 = 3.3 time = 940
* CHECK dout0_14 vdout0_14ck187 = 3.3 time = 940
* CHECK dout0_15 vdout0_15ck187 = 3.3 time = 940
* CHECK dout0_16 vdout0_16ck187 = 0 time = 940
* CHECK dout0_17 vdout0_17ck187 = 0 time = 940
* CHECK dout0_18 vdout0_18ck187 = 0 time = 940
* CHECK dout0_19 vdout0_19ck187 = 0 time = 940
* CHECK dout0_20 vdout0_20ck187 = 3.3 time = 940
* CHECK dout0_21 vdout0_21ck187 = 3.3 time = 940
* CHECK dout0_22 vdout0_22ck187 = 0 time = 940
* CHECK dout0_23 vdout0_23ck187 = 3.3 time = 940
* CHECK dout0_24 vdout0_24ck187 = 3.3 time = 940
* CHECK dout0_25 vdout0_25ck187 = 0 time = 940
* CHECK dout0_26 vdout0_26ck187 = 3.3 time = 940
* CHECK dout0_27 vdout0_27ck187 = 0 time = 940
* CHECK dout0_28 vdout0_28ck187 = 3.3 time = 940
* CHECK dout0_29 vdout0_29ck187 = 0 time = 940
* CHECK dout0_30 vdout0_30ck187 = 0 time = 940
* CHECK dout0_31 vdout0_31ck187 = 0 time = 940
* CHECK dout0_0 vdout0_0ck188 = 3.3 time = 945
* CHECK dout0_1 vdout0_1ck188 = 3.3 time = 945
* CHECK dout0_2 vdout0_2ck188 = 3.3 time = 945
* CHECK dout0_3 vdout0_3ck188 = 0 time = 945
* CHECK dout0_4 vdout0_4ck188 = 0 time = 945
* CHECK dout0_5 vdout0_5ck188 = 0 time = 945
* CHECK dout0_6 vdout0_6ck188 = 0 time = 945
* CHECK dout0_7 vdout0_7ck188 = 3.3 time = 945
* CHECK dout0_8 vdout0_8ck188 = 3.3 time = 945
* CHECK dout0_9 vdout0_9ck188 = 0 time = 945
* CHECK dout0_10 vdout0_10ck188 = 3.3 time = 945
* CHECK dout0_11 vdout0_11ck188 = 3.3 time = 945
* CHECK dout0_12 vdout0_12ck188 = 0 time = 945
* CHECK dout0_13 vdout0_13ck188 = 3.3 time = 945
* CHECK dout0_14 vdout0_14ck188 = 3.3 time = 945
* CHECK dout0_15 vdout0_15ck188 = 0 time = 945
* CHECK dout0_16 vdout0_16ck188 = 3.3 time = 945
* CHECK dout0_17 vdout0_17ck188 = 0 time = 945
* CHECK dout0_18 vdout0_18ck188 = 0 time = 945
* CHECK dout0_19 vdout0_19ck188 = 0 time = 945
* CHECK dout0_20 vdout0_20ck188 = 0 time = 945
* CHECK dout0_21 vdout0_21ck188 = 0 time = 945
* CHECK dout0_22 vdout0_22ck188 = 0 time = 945
* CHECK dout0_23 vdout0_23ck188 = 3.3 time = 945
* CHECK dout0_24 vdout0_24ck188 = 0 time = 945
* CHECK dout0_25 vdout0_25ck188 = 0 time = 945
* CHECK dout0_26 vdout0_26ck188 = 3.3 time = 945
* CHECK dout0_27 vdout0_27ck188 = 3.3 time = 945
* CHECK dout0_28 vdout0_28ck188 = 3.3 time = 945
* CHECK dout0_29 vdout0_29ck188 = 0 time = 945
* CHECK dout0_30 vdout0_30ck188 = 0 time = 945
* CHECK dout0_31 vdout0_31ck188 = 0 time = 945
* CHECK dout0_0 vdout0_0ck189 = 0 time = 950
* CHECK dout0_1 vdout0_1ck189 = 0 time = 950
* CHECK dout0_2 vdout0_2ck189 = 3.3 time = 950
* CHECK dout0_3 vdout0_3ck189 = 0 time = 950
* CHECK dout0_4 vdout0_4ck189 = 0 time = 950
* CHECK dout0_5 vdout0_5ck189 = 0 time = 950
* CHECK dout0_6 vdout0_6ck189 = 0 time = 950
* CHECK dout0_7 vdout0_7ck189 = 0 time = 950
* CHECK dout0_8 vdout0_8ck189 = 0 time = 950
* CHECK dout0_9 vdout0_9ck189 = 0 time = 950
* CHECK dout0_10 vdout0_10ck189 = 3.3 time = 950
* CHECK dout0_11 vdout0_11ck189 = 3.3 time = 950
* CHECK dout0_12 vdout0_12ck189 = 0 time = 950
* CHECK dout0_13 vdout0_13ck189 = 3.3 time = 950
* CHECK dout0_14 vdout0_14ck189 = 3.3 time = 950
* CHECK dout0_15 vdout0_15ck189 = 3.3 time = 950
* CHECK dout0_16 vdout0_16ck189 = 0 time = 950
* CHECK dout0_17 vdout0_17ck189 = 0 time = 950
* CHECK dout0_18 vdout0_18ck189 = 0 time = 950
* CHECK dout0_19 vdout0_19ck189 = 0 time = 950
* CHECK dout0_20 vdout0_20ck189 = 3.3 time = 950
* CHECK dout0_21 vdout0_21ck189 = 3.3 time = 950
* CHECK dout0_22 vdout0_22ck189 = 0 time = 950
* CHECK dout0_23 vdout0_23ck189 = 3.3 time = 950
* CHECK dout0_24 vdout0_24ck189 = 3.3 time = 950
* CHECK dout0_25 vdout0_25ck189 = 0 time = 950
* CHECK dout0_26 vdout0_26ck189 = 3.3 time = 950
* CHECK dout0_27 vdout0_27ck189 = 0 time = 950
* CHECK dout0_28 vdout0_28ck189 = 3.3 time = 950
* CHECK dout0_29 vdout0_29ck189 = 0 time = 950
* CHECK dout0_30 vdout0_30ck189 = 0 time = 950
* CHECK dout0_31 vdout0_31ck189 = 0 time = 950
* CHECK dout0_0 vdout0_0ck190 = 3.3 time = 955
* CHECK dout0_1 vdout0_1ck190 = 3.3 time = 955
* CHECK dout0_2 vdout0_2ck190 = 3.3 time = 955
* CHECK dout0_3 vdout0_3ck190 = 0 time = 955
* CHECK dout0_4 vdout0_4ck190 = 0 time = 955
* CHECK dout0_5 vdout0_5ck190 = 0 time = 955
* CHECK dout0_6 vdout0_6ck190 = 0 time = 955
* CHECK dout0_7 vdout0_7ck190 = 3.3 time = 955
* CHECK dout0_8 vdout0_8ck190 = 3.3 time = 955
* CHECK dout0_9 vdout0_9ck190 = 0 time = 955
* CHECK dout0_10 vdout0_10ck190 = 3.3 time = 955
* CHECK dout0_11 vdout0_11ck190 = 3.3 time = 955
* CHECK dout0_12 vdout0_12ck190 = 0 time = 955
* CHECK dout0_13 vdout0_13ck190 = 3.3 time = 955
* CHECK dout0_14 vdout0_14ck190 = 3.3 time = 955
* CHECK dout0_15 vdout0_15ck190 = 0 time = 955
* CHECK dout0_16 vdout0_16ck190 = 3.3 time = 955
* CHECK dout0_17 vdout0_17ck190 = 0 time = 955
* CHECK dout0_18 vdout0_18ck190 = 0 time = 955
* CHECK dout0_19 vdout0_19ck190 = 0 time = 955
* CHECK dout0_20 vdout0_20ck190 = 0 time = 955
* CHECK dout0_21 vdout0_21ck190 = 0 time = 955
* CHECK dout0_22 vdout0_22ck190 = 0 time = 955
* CHECK dout0_23 vdout0_23ck190 = 3.3 time = 955
* CHECK dout0_24 vdout0_24ck190 = 0 time = 955
* CHECK dout0_25 vdout0_25ck190 = 0 time = 955
* CHECK dout0_26 vdout0_26ck190 = 3.3 time = 955
* CHECK dout0_27 vdout0_27ck190 = 3.3 time = 955
* CHECK dout0_28 vdout0_28ck190 = 3.3 time = 955
* CHECK dout0_29 vdout0_29ck190 = 0 time = 955
* CHECK dout0_30 vdout0_30ck190 = 0 time = 955
* CHECK dout0_31 vdout0_31ck190 = 0 time = 955
* CHECK dout0_0 vdout0_0ck193 = 3.3 time = 970
* CHECK dout0_1 vdout0_1ck193 = 3.3 time = 970
* CHECK dout0_2 vdout0_2ck193 = 3.3 time = 970
* CHECK dout0_3 vdout0_3ck193 = 0 time = 970
* CHECK dout0_4 vdout0_4ck193 = 0 time = 970
* CHECK dout0_5 vdout0_5ck193 = 0 time = 970
* CHECK dout0_6 vdout0_6ck193 = 0 time = 970
* CHECK dout0_7 vdout0_7ck193 = 3.3 time = 970
* CHECK dout0_8 vdout0_8ck193 = 3.3 time = 970
* CHECK dout0_9 vdout0_9ck193 = 0 time = 970
* CHECK dout0_10 vdout0_10ck193 = 3.3 time = 970
* CHECK dout0_11 vdout0_11ck193 = 3.3 time = 970
* CHECK dout0_12 vdout0_12ck193 = 0 time = 970
* CHECK dout0_13 vdout0_13ck193 = 3.3 time = 970
* CHECK dout0_14 vdout0_14ck193 = 3.3 time = 970
* CHECK dout0_15 vdout0_15ck193 = 0 time = 970
* CHECK dout0_16 vdout0_16ck193 = 3.3 time = 970
* CHECK dout0_17 vdout0_17ck193 = 0 time = 970
* CHECK dout0_18 vdout0_18ck193 = 0 time = 970
* CHECK dout0_19 vdout0_19ck193 = 0 time = 970
* CHECK dout0_20 vdout0_20ck193 = 0 time = 970
* CHECK dout0_21 vdout0_21ck193 = 0 time = 970
* CHECK dout0_22 vdout0_22ck193 = 0 time = 970
* CHECK dout0_23 vdout0_23ck193 = 3.3 time = 970
* CHECK dout0_24 vdout0_24ck193 = 0 time = 970
* CHECK dout0_25 vdout0_25ck193 = 0 time = 970
* CHECK dout0_26 vdout0_26ck193 = 3.3 time = 970
* CHECK dout0_27 vdout0_27ck193 = 3.3 time = 970
* CHECK dout0_28 vdout0_28ck193 = 3.3 time = 970
* CHECK dout0_29 vdout0_29ck193 = 0 time = 970
* CHECK dout0_30 vdout0_30ck193 = 0 time = 970
* CHECK dout0_31 vdout0_31ck193 = 0 time = 970
* CHECK dout0_0 vdout0_0ck194 = 3.3 time = 975
* CHECK dout0_1 vdout0_1ck194 = 3.3 time = 975
* CHECK dout0_2 vdout0_2ck194 = 3.3 time = 975
* CHECK dout0_3 vdout0_3ck194 = 3.3 time = 975
* CHECK dout0_4 vdout0_4ck194 = 0 time = 975
* CHECK dout0_5 vdout0_5ck194 = 0 time = 975
* CHECK dout0_6 vdout0_6ck194 = 0 time = 975
* CHECK dout0_7 vdout0_7ck194 = 0 time = 975
* CHECK dout0_8 vdout0_8ck194 = 3.3 time = 975
* CHECK dout0_9 vdout0_9ck194 = 3.3 time = 975
* CHECK dout0_10 vdout0_10ck194 = 0 time = 975
* CHECK dout0_11 vdout0_11ck194 = 3.3 time = 975
* CHECK dout0_12 vdout0_12ck194 = 0 time = 975
* CHECK dout0_13 vdout0_13ck194 = 0 time = 975
* CHECK dout0_14 vdout0_14ck194 = 3.3 time = 975
* CHECK dout0_15 vdout0_15ck194 = 0 time = 975
* CHECK dout0_16 vdout0_16ck194 = 3.3 time = 975
* CHECK dout0_17 vdout0_17ck194 = 0 time = 975
* CHECK dout0_18 vdout0_18ck194 = 0 time = 975
* CHECK dout0_19 vdout0_19ck194 = 0 time = 975
* CHECK dout0_20 vdout0_20ck194 = 0 time = 975
* CHECK dout0_21 vdout0_21ck194 = 3.3 time = 975
* CHECK dout0_22 vdout0_22ck194 = 3.3 time = 975
* CHECK dout0_23 vdout0_23ck194 = 0 time = 975
* CHECK dout0_24 vdout0_24ck194 = 3.3 time = 975
* CHECK dout0_25 vdout0_25ck194 = 0 time = 975
* CHECK dout0_26 vdout0_26ck194 = 0 time = 975
* CHECK dout0_27 vdout0_27ck194 = 0 time = 975
* CHECK dout0_28 vdout0_28ck194 = 0 time = 975
* CHECK dout0_29 vdout0_29ck194 = 3.3 time = 975
* CHECK dout0_30 vdout0_30ck194 = 0 time = 975
* CHECK dout0_31 vdout0_31ck194 = 3.3 time = 975
* CHECK dout0_0 vdout0_0ck197 = 3.3 time = 990
* CHECK dout0_1 vdout0_1ck197 = 0 time = 990
* CHECK dout0_2 vdout0_2ck197 = 0 time = 990
* CHECK dout0_3 vdout0_3ck197 = 3.3 time = 990
* CHECK dout0_4 vdout0_4ck197 = 0 time = 990
* CHECK dout0_5 vdout0_5ck197 = 3.3 time = 990
* CHECK dout0_6 vdout0_6ck197 = 0 time = 990
* CHECK dout0_7 vdout0_7ck197 = 3.3 time = 990
* CHECK dout0_8 vdout0_8ck197 = 3.3 time = 990
* CHECK dout0_9 vdout0_9ck197 = 3.3 time = 990
* CHECK dout0_10 vdout0_10ck197 = 0 time = 990
* CHECK dout0_11 vdout0_11ck197 = 0 time = 990
* CHECK dout0_12 vdout0_12ck197 = 3.3 time = 990
* CHECK dout0_13 vdout0_13ck197 = 0 time = 990
* CHECK dout0_14 vdout0_14ck197 = 3.3 time = 990
* CHECK dout0_15 vdout0_15ck197 = 0 time = 990
* CHECK dout0_16 vdout0_16ck197 = 3.3 time = 990
* CHECK dout0_17 vdout0_17ck197 = 3.3 time = 990
* CHECK dout0_18 vdout0_18ck197 = 3.3 time = 990
* CHECK dout0_19 vdout0_19ck197 = 0 time = 990
* CHECK dout0_20 vdout0_20ck197 = 3.3 time = 990
* CHECK dout0_21 vdout0_21ck197 = 3.3 time = 990
* CHECK dout0_22 vdout0_22ck197 = 3.3 time = 990
* CHECK dout0_23 vdout0_23ck197 = 3.3 time = 990
* CHECK dout0_24 vdout0_24ck197 = 3.3 time = 990
* CHECK dout0_25 vdout0_25ck197 = 0 time = 990
* CHECK dout0_26 vdout0_26ck197 = 3.3 time = 990
* CHECK dout0_27 vdout0_27ck197 = 3.3 time = 990
* CHECK dout0_28 vdout0_28ck197 = 0 time = 990
* CHECK dout0_29 vdout0_29ck197 = 3.3 time = 990
* CHECK dout0_30 vdout0_30ck197 = 3.3 time = 990
* CHECK dout0_31 vdout0_31ck197 = 0 time = 990
* CHECK dout0_0 vdout0_0ck198 = 3.3 time = 995
* CHECK dout0_1 vdout0_1ck198 = 0 time = 995
* CHECK dout0_2 vdout0_2ck198 = 0 time = 995
* CHECK dout0_3 vdout0_3ck198 = 3.3 time = 995
* CHECK dout0_4 vdout0_4ck198 = 0 time = 995
* CHECK dout0_5 vdout0_5ck198 = 3.3 time = 995
* CHECK dout0_6 vdout0_6ck198 = 0 time = 995
* CHECK dout0_7 vdout0_7ck198 = 3.3 time = 995
* CHECK dout0_8 vdout0_8ck198 = 3.3 time = 995
* CHECK dout0_9 vdout0_9ck198 = 3.3 time = 995
* CHECK dout0_10 vdout0_10ck198 = 0 time = 995
* CHECK dout0_11 vdout0_11ck198 = 0 time = 995
* CHECK dout0_12 vdout0_12ck198 = 3.3 time = 995
* CHECK dout0_13 vdout0_13ck198 = 0 time = 995
* CHECK dout0_14 vdout0_14ck198 = 3.3 time = 995
* CHECK dout0_15 vdout0_15ck198 = 0 time = 995
* CHECK dout0_16 vdout0_16ck198 = 3.3 time = 995
* CHECK dout0_17 vdout0_17ck198 = 3.3 time = 995
* CHECK dout0_18 vdout0_18ck198 = 3.3 time = 995
* CHECK dout0_19 vdout0_19ck198 = 0 time = 995
* CHECK dout0_20 vdout0_20ck198 = 3.3 time = 995
* CHECK dout0_21 vdout0_21ck198 = 3.3 time = 995
* CHECK dout0_22 vdout0_22ck198 = 3.3 time = 995
* CHECK dout0_23 vdout0_23ck198 = 3.3 time = 995
* CHECK dout0_24 vdout0_24ck198 = 3.3 time = 995
* CHECK dout0_25 vdout0_25ck198 = 0 time = 995
* CHECK dout0_26 vdout0_26ck198 = 3.3 time = 995
* CHECK dout0_27 vdout0_27ck198 = 3.3 time = 995
* CHECK dout0_28 vdout0_28ck198 = 0 time = 995
* CHECK dout0_29 vdout0_29ck198 = 3.3 time = 995
* CHECK dout0_30 vdout0_30ck198 = 3.3 time = 995
* CHECK dout0_31 vdout0_31ck198 = 0 time = 995
* CHECK dout0_0 vdout0_0ck199 = 3.3 time = 1000
* CHECK dout0_1 vdout0_1ck199 = 3.3 time = 1000
* CHECK dout0_2 vdout0_2ck199 = 3.3 time = 1000
* CHECK dout0_3 vdout0_3ck199 = 0 time = 1000
* CHECK dout0_4 vdout0_4ck199 = 0 time = 1000
* CHECK dout0_5 vdout0_5ck199 = 0 time = 1000
* CHECK dout0_6 vdout0_6ck199 = 0 time = 1000
* CHECK dout0_7 vdout0_7ck199 = 3.3 time = 1000
* CHECK dout0_8 vdout0_8ck199 = 3.3 time = 1000
* CHECK dout0_9 vdout0_9ck199 = 0 time = 1000
* CHECK dout0_10 vdout0_10ck199 = 3.3 time = 1000
* CHECK dout0_11 vdout0_11ck199 = 3.3 time = 1000
* CHECK dout0_12 vdout0_12ck199 = 0 time = 1000
* CHECK dout0_13 vdout0_13ck199 = 3.3 time = 1000
* CHECK dout0_14 vdout0_14ck199 = 3.3 time = 1000
* CHECK dout0_15 vdout0_15ck199 = 0 time = 1000
* CHECK dout0_16 vdout0_16ck199 = 3.3 time = 1000
* CHECK dout0_17 vdout0_17ck199 = 0 time = 1000
* CHECK dout0_18 vdout0_18ck199 = 0 time = 1000
* CHECK dout0_19 vdout0_19ck199 = 0 time = 1000
* CHECK dout0_20 vdout0_20ck199 = 0 time = 1000
* CHECK dout0_21 vdout0_21ck199 = 0 time = 1000
* CHECK dout0_22 vdout0_22ck199 = 0 time = 1000
* CHECK dout0_23 vdout0_23ck199 = 3.3 time = 1000
* CHECK dout0_24 vdout0_24ck199 = 0 time = 1000
* CHECK dout0_25 vdout0_25ck199 = 0 time = 1000
* CHECK dout0_26 vdout0_26ck199 = 3.3 time = 1000
* CHECK dout0_27 vdout0_27ck199 = 3.3 time = 1000
* CHECK dout0_28 vdout0_28ck199 = 3.3 time = 1000
* CHECK dout0_29 vdout0_29ck199 = 0 time = 1000
* CHECK dout0_30 vdout0_30ck199 = 0 time = 1000
* CHECK dout0_31 vdout0_31ck199 = 0 time = 1000
* CHECK dout0_0 vdout0_0ck200 = 3.3 time = 1005
* CHECK dout0_1 vdout0_1ck200 = 0 time = 1005
* CHECK dout0_2 vdout0_2ck200 = 0 time = 1005
* CHECK dout0_3 vdout0_3ck200 = 3.3 time = 1005
* CHECK dout0_4 vdout0_4ck200 = 0 time = 1005
* CHECK dout0_5 vdout0_5ck200 = 3.3 time = 1005
* CHECK dout0_6 vdout0_6ck200 = 0 time = 1005
* CHECK dout0_7 vdout0_7ck200 = 3.3 time = 1005
* CHECK dout0_8 vdout0_8ck200 = 3.3 time = 1005
* CHECK dout0_9 vdout0_9ck200 = 3.3 time = 1005
* CHECK dout0_10 vdout0_10ck200 = 0 time = 1005
* CHECK dout0_11 vdout0_11ck200 = 0 time = 1005
* CHECK dout0_12 vdout0_12ck200 = 3.3 time = 1005
* CHECK dout0_13 vdout0_13ck200 = 0 time = 1005
* CHECK dout0_14 vdout0_14ck200 = 3.3 time = 1005
* CHECK dout0_15 vdout0_15ck200 = 0 time = 1005
* CHECK dout0_16 vdout0_16ck200 = 3.3 time = 1005
* CHECK dout0_17 vdout0_17ck200 = 3.3 time = 1005
* CHECK dout0_18 vdout0_18ck200 = 3.3 time = 1005
* CHECK dout0_19 vdout0_19ck200 = 0 time = 1005
* CHECK dout0_20 vdout0_20ck200 = 3.3 time = 1005
* CHECK dout0_21 vdout0_21ck200 = 3.3 time = 1005
* CHECK dout0_22 vdout0_22ck200 = 3.3 time = 1005
* CHECK dout0_23 vdout0_23ck200 = 3.3 time = 1005
* CHECK dout0_24 vdout0_24ck200 = 3.3 time = 1005
* CHECK dout0_25 vdout0_25ck200 = 0 time = 1005
* CHECK dout0_26 vdout0_26ck200 = 3.3 time = 1005
* CHECK dout0_27 vdout0_27ck200 = 3.3 time = 1005
* CHECK dout0_28 vdout0_28ck200 = 0 time = 1005
* CHECK dout0_29 vdout0_29ck200 = 3.3 time = 1005
* CHECK dout0_30 vdout0_30ck200 = 3.3 time = 1005
* CHECK dout0_31 vdout0_31ck200 = 0 time = 1005
.include /home/v62893/mydata/OpenRAM/OpenRAM/sram_output_freepdk45/functional_meas.sp
* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
